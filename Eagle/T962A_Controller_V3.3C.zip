# EAGLE board T962A_Controller_V3.0B (EAGLE 7.7.0), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
LCD_DE  (via drill 0.25 pad 0.51) (continued)
  Top 0.152: 69.72,3.23 69.42,2.92 63.63,2.92 62.81,3.73 62.81,14.64 R38.1 | 69.72,3.23 69.72,7.09 69.7,7.11 J1.34 | v158.17,3.25 157.38,2.46 105.05,2.46 103.94,3.58 95.05,3.58 94.39,2.92 70.03,2.92 69.72,3.23 | v185.45,28.35 185.45,27.74 185.48,27.71 U1.28
  Bottom 0.152: v158.17,3.25 171.93,3.25 175.11,6.43 175.11,26.44 178.28,29.62 184.18,29.62 v185.45,28.35
LCD_G0
  Top 0.152: RN14.4 82.38,20.93 82.78,21.34 170.71,21.34 171.12,21.74 171.12,28.75 172.72,30.35 176.28,30.35 179.46,33.54 179.46,34.21 180.28,35.03 U1.57
LCD_G1  (via drill 0.25 pad 0.51)
  Top 0.152: v170.59,22.2 170.03,21.64 81.99,21.64 81.58,21.23 RN14.3 | v181.23,33.05 192.24,33.05 193.72,34.53 U1.56
  Bottom 0.152: v181.23,33.05 174.02,33.05 170.84,29.87 170.84,22.45 v170.59,22.2
LCD_G2  (via drill 0.25 pad 0.51)
  Top 0.152: v152.65,53.65 159.82,53.65 160.1,53.92 173.76,53.92 173.98,53.71 U1.128 | v152.65,22.5 81.58,22.5 80.78,21.7 RN14.2
  Bottom 0.152: v152.65,22.5 v152.65,53.65
LCD_G3  (via drill 0.25 pad 0.51)
  Top 0.152: v152.12,52.98 168.07,52.98 168.71,53.62 173.48,53.62 U1.129 | v83.31,20.85 v152.12,20.85 | v79.98,15.19 v79.98,15.18 RN14.1
  Bottom 0.152: v152.12,20.85 v152.12,52.98 | v79.98,15.19 83.32,18.52 83.32,20.85 v83.31,20.85
LCD_G4  (via drill 0.25 pad 0.51)
  Top 0.152: v149.4,51.38 149.58,51.56 168.86,51.56 169.52,50.9 172.77,50.9 172.98,51.11 U1.130 | v149.4,23.47 81,23.47 79.4,21.87 79.4,16.69 78.62,15.91 RN15.4
  Bottom 0.152: v149.4,23.47 v149.4,51.38
LCD_G5  (via drill 0.25 pad 0.51)
  Top 0.152: v76.71,17.25 77.42,17.25 77.82,16.85 RN15.3 | v74.22,28.42 141.4,28.42 142.99,30.02 142.99,51.05 143.81,51.87 169.82,51.87 170.48,51.21 172.31,51.21 172.48,51.37 U1.131
  Bottom 0.152: v74.22,28.42 74.22,19.74 v76.71,17.25
LCD_G6  (via drill 0.25 pad 0.51)
  Top 0.152: v73.13,28.02 74.55,29.44 141.58,29.44 141.99,29.84 141.99,52.32 143.59,53.92 148.56,53.92 149.99,52.5 U1.132 | v77.22,16.76 77.02,16.57 RN15.2
  Bottom 0.152: v77.22,16.76 76.3,16.76 73.13,19.94 v73.13,28.02
LCD_G7  (via drill 0.25 pad 0.51)
  Top 0.152: v150.24,23.8 150.09,23.95 80.7,23.95 79.1,22.35 79.1,20.94 76.22,18.06 RN15.1 | v150.24,51.08 150.27,51.11 168.31,51.11 168.88,50.53 U1.133
  Bottom 0.152: v150.24,51.08 v150.24,23.8
LCD_HSYNC  (via drill 0.25 pad 0.51)
  Top 0.152: RN6.6 RN18.2 65.67,13.59 65.46,13.39 v64.39,13.39 | v175.9,16.89 194.51,16.89 195.33,17.7 195.33,18.24 195.12,18.44 180.49,18.44 178.89,20.04 178.89,23.01 177.29,24.61 177.29,25.6 177.48,25.79 U1.12
  Bottom 0.152: v64.39,13.39 60.3,9.3 60.3,2.11 61.11,1.29 172.72,1.29 175.9,4.47 v175.9,16.89
LCD_LED+  (via drill 0.25 pad 0.51)
  Top 0.152: C15.1 v244.17,69.77 | C41.1 100.45,4.48 99.95,4.98 C40.+ 97.21,6.2 86.11,6.2 85.7,6.6 J1.2
  Top 0.203: D1.C 251.32,73.19 R45.2 C15.1
  Bottom 0.152: C40.+ 108.97,4.98 111.48,2.46 172.24,2.46 175.41,5.64 175.41,20.35 176.23,21.16 177.52,21.16 177.52,4.24 178.33,3.43 231.47,3.43 244.17,16.13 v244.17,69.77
LCD_LED_FB
  Top 0.152: R45.1 253.02,72.06 253.16,71.92 R61.1 255.04,71.62 256.86,71.62 U$1.3
LCD_R0  (via drill 0.25 pad 0.51)
  Top 0.152: v198.68,16.46 202.36,16.46 203.17,15.65 203.17,15.09 202.77,14.68 160.43,14.68 160.27,14.83 89.87,14.83 RN12.4 | v192.99,28.35 192.98,28.34 U1.43
  Bottom 0.152: v192.99,28.35 197.87,28.35 198.68,27.53 v198.68,16.46
LCD_R1  (via drill 0.25 pad 0.51)
  Top 0.152: v194.84,17.96 194.36,17.48 90.68,17.48 89.07,15.87 RN12.3 | RN12.3 | v194.84,27.05 U1.44
  Bottom 0.152: v194.84,27.05 v194.84,17.96
LCD_R2  (via drill 0.25 pad 0.51)
  Top 0.152: v192.13,34.24 181.56,34.24 180.75,33.43 180.75,33.22 177.57,30.05 173.02,30.05 171.42,28.45 171.42,20.6 170.61,19.79 160.27,19.79 159.87,19.38 159.87,18.19 159.46,17.78 89.87,17.78 88.27,16.19 RN12.2 | v194.16,48.87 194.31,49.03 U1.85
  Bottom 0.152: v194.16,48.87 192.81,47.52 192.81,34.93 v192.13,34.24
LCD_R3  (via drill 0.25 pad 0.51)
  Top 0.152: v195.33,14.07 101.12,14.07 100.31,13.26 100.31,10.95 97.13,7.77 92.28,7.77 90.68,9.37 90.68,12.8 89.87,13.61 87.47,13.61 RN12.1 | v192.33,37.06 v189.18,37.06 | v193.27,49.35 193.44,49.53 U1.86
  Bottom 0.152: v189.18,37.06 189.18,29.13 190.78,27.53 195.12,27.53 195.33,27.33 v195.33,14.07 | v193.27,49.35 192.41,48.49 192.41,37.13 v192.33,37.06
LCD_R4  (via drill 0.25 pad 0.51)
  Top 0.152: v171.91,48.23 191.01,48.23 192.8,50.03 U1.87 | v151.64,18.92 87.73,18.92 86.14,17.33 RN13.4
  Bottom 0.152: v151.64,18.92 151.64,53.9 152.45,54.71 157.1,54.71 160.27,51.54 160.27,46.43 160.48,46.23 169.9,46.23 v171.91,48.23
LCD_R5  (via drill 0.25 pad 0.51)
  Top 0.152: v195.45,51.08 U1.88 | v172.57,38.84 v191.92,38.84 | v169.8,20.4 154.76,20.4 153.77,19.41 86.94,19.41 85.34,17.8 RN13.3
  Bottom 0.152: v191.92,38.84 191.92,49.02 192.74,49.84 195.05,49.84 195.45,50.24 v195.45,51.08 | v169.8,20.4 169.8,36.07 v172.57,38.84
LCD_R6  (via drill 0.25 pad 0.51)
  Top 0.152: v84.56,15.19 84.56,14.45 84.54,14.43 RN13.2 | v178.44,58.98 178.23,59.18 v142.98,59.18 | v206.2,51.87 206.02,52.05 198.12,52.05 197.66,52.5 U1.89
  Bottom 0.152: v142.98,59.18 142.98,28.32 142.16,27.51 90.91,27.51 84.56,21.16 v84.56,15.19 | v206.2,51.87 206.2,54.53 205.79,54.94 203.15,54.94 199.97,58.12 199.97,58.17 199.16,58.98 v178.44,58.98
LCD_R7  (via drill 0.25 pad 0.51)
  Top 0.152: v176.15,50.19 182.17,50.19 182.98,51 U1.110 | v152.45,19.89 85.34,19.89 83.74,18.28 RN13.1
  Bottom 0.152: v152.45,19.89 153.14,20.57 153.14,33.93 157.58,38.38 157.58,50.29 158.39,51.11 159.16,51.11 159.97,50.29 159.97,46.13 160.17,45.92 171.83,45.92 173.43,47.52 173.43,50.47 174.24,51.28 175.34,50.19 v176.15,50.19
LCD_STBY  (via drill 0.25 pad 0.51)
  Top 0.152: 66.47,15.14 RN18.3 | v67.95,15.14 66.47,15.14 | 66.47,15.14 RN6.7 | v143.48,38.68 146.84,38.68 148.64,40.49 166.78,40.49 167.36,41.07 168.28,41.07 168.32,41.03 U1.152
  Bottom 0.152: v67.95,15.14 69.29,13.79 87.48,13.79 88.93,15.24 136.93,15.24 143.28,21.59 143.28,38.48 v143.48,38.68
LCD_VSYNC  (via drill 0.25 pad 0.51)
  Top 0.152: RN18.1 RN6.5 61.75,15.84 60.93,15.03 60.93,4.65 62.04,3.54 62.04,3.43 62.85,2.62 96.95,2.62 97.61,3.28 99.26,3.28 100.46,2.08 v101.52,2.08 | v167.72,17.96 175.74,17.96 177.34,19.56 177.34,23.8 176.98,24.17 U1.11 | v161.54,1.98 v161.54,3.79
  Bottom 0.152: v161.54,3.79 166.9,3.79 167.72,4.6 v167.72,17.96 | v101.52,2.08 161.44,2.08 v161.54,1.98
MCO1  (via drill 0.25 pad 0.51)  (1 unrouted)
  Top 0.152: v173.63,28.35 173.48,28.19 U1.4 | v180.21,51.21 178.64,51.21 178.48,51.37 U1.119
  Bottom 0.152: v180.21,51.21 180.21,45.34 182.17,43.38 182.17,33.2 180.57,31.6 174.45,31.6 173.63,30.79 v173.63,28.35
N$1  (via drill 0.25 pad 0.51)
  Top 0.152: L4.2 207.67,15.72 C4.1 206.74,15.72 C2.1 206.74,19.11 v206.73,19.13 | v206.73,23.17 191.03,23.17 190.63,23.57 190.63,24.51 190.98,24.86 U1.39
  Bottom 0.152: v206.73,19.13 v206.73,23.17
N$2
  Top 0.152: SV1.3 145.42,49.4 154.14,49.4 R1.2
N$3
  Top 0.152: SV1.5 145.67,46.61 153.95,46.61 154.17,46.83 R3.2
N$4
  Top 0.152: LED1.C R2.1
N$5
  Top 0.152: SV1.7 145.42,46.3 153.95,46.3 154.17,46.09 R4.2
N$6
  Top 0.152: LED5.C R5.2
N$7
  Top 0.152: SV1.9 145.42,43.76 153.92,43.76 154.14,43.55 R7.2
N$9
  Top 0.152: SV1.13 145.67,36.45 154.13,36.45 154.34,36.67 R8.2
N$10
  Top 0.152: SV1.15 145.42,36.14 154.18,36.14 154.39,35.93 R9.2
N$12  (via drill 0.25 pad 0.51)
  Top 0.152: v169.09,7.26 R11.1
  Bottom 0.152: v169.09,7.26 169.04,7.21 JP1.2
N$13  (via drill 0.25 pad 0.51)
  Top 0.152: R59.1 R60.2 197.78,18.57 197.01,19.33 v191.82,19.33 | v189.51,25.07 190.07,25.07 190.48,25.48 U1.38
  Bottom 0.152: v189.51,25.07 191.83,22.75 v191.83,19.34 v191.82,19.33
N$14  (via drill 0.25 pad 0.51)
  Top 0.152: v196.75,47.02 196.74,47.03 U1.81 | v197.26,55.37 C10.1
  Bottom 0.152: v197.26,55.37 197.26,47.52 v196.75,47.02
N$15  (via drill 0.25 pad 0.51)
  Top 0.152: v175.01,57.4 C9.1 | v175.49,53.8 175.48,53.79 U1.125
  Bottom 0.152: v175.49,53.8 175.01,54.28 v175.01,57.4
N$16
  Top 0.152: U$15.23 RN5.8
N$17
  Top 0.152: U$15.26 RN5.5
N$18
  Top 0.152: U$15.25 RN5.6
N$19
  Top 0.152: U$15.24 RN5.7
N$20  (via drill 0.25 pad 0.51)
  Top 0.152: v228.45,44.91 226.8,44.91 U$15.29 | v228.63,46.69 228.61,46.67 RN7.8
  Bottom 0.152: v228.63,46.69 228.63,45.09 v228.45,44.91
N$21  (via drill 0.25 pad 0.51)
  Top 0.152: 193.68,42.53 193.37,42.22 193.37,37.83 193.68,37.53 | 193.68,37.53 v193.68,35.92 v184.05,35.92 179.57,35.92 177.97,34.31 177.97,34.22 174.78,31.03 U1.172 166.37,31.03 165.57,30.23 165.57,29.82 163.97,28.22 160.73,28.22 v160.38,27.86 | C39.+ 220.24,53.14 194.92,53.14 194.11,53.95 v192.79,53.95 192.79,53.62 192.48,53.62 U1.91 | v182.78,48.87 v174.32,48.87 173,48.87 172.85,49.03 U1.136 165.2,49.03 v163.8,50.42 | 193.68,37.53 U1.62 | L8.2 231.14,58.16 230.84,57.86 v230.84,57.28 C29.1 | v230.78,54.63 C26.1 | 193.68,42.53 193.37,42.83 193.37,46.71 194.19,47.53 U1.82 | U1.36 189.48,28.43 189.08,28.83 v188.26,28.83 183.18,28.83 182.98,28.63 U1.23 v182.98,25.76 | U1.159 171.77,37.53 172.09,37.85 v172.09,42.37 171.28,42.37 171.12,42.53 U1.149 | v174.32,50.5 174.48,50.65 U1.127 | 193.68,42.53 193.7,42.53 | 193.7,42.53 | 193.7,42.53 U1.72 | v180.92,51.21 180.92,51.79 180.98,51.84 U1.114 | v196.75,31.04 196.74,31.03 U1.49 | v186.49,56.46 191.69,56.46 v192.79,55.37 | v178.99,28.83 178.99,27.73 178.98,27.71 U1.15 | v186.49,53.8 v186.48,53.79 U1.103
  Bottom 0.152: v188.26,28.83 188.26,31.7 v184.05,35.92 184.05,47.6 v182.78,48.87 182.78,50.9 182.47,51.21 | 182.47,51.21 182.47,56.74 182.88,57.15 185.8,57.15 v186.49,56.46 v186.49,53.8 | v174.32,50.5 v174.32,48.87 174.32,44.6 v172.09,42.37 | C39.+ 229.49,58.62 v230.84,57.28 230.84,54.69 v230.78,54.63 | 182.47,51.21 v180.92,51.21 | v193.68,35.92 193.68,31.45 194.08,31.04 v196.75,31.04 | v192.79,53.95 v192.79,55.37 | v160.38,27.86 160.38,10.41 154.03,4.06 JP4.1 | v163.8,50.42 C38.+ | v182.98,25.76 179.91,28.83 v178.99,28.83
N$22
  Top 0.152: RN7.7 227.15,45.8 227.55,45.39 228.73,45.39 228.93,45.19 228.93,42.93 228.52,42.52 226.21,42.52 226,42.74 U$15.30
N$23
  Top 0.152: U$15.31 225.2,44.91 225.93,44.91 226.35,45.32 RN7.6
N$24
  Top 0.152: U$15.32 224.4,45.01 224.6,45.21 225.15,45.21 225.55,45.61 RN7.5
N$25
  Top 0.152: RN8.8 224.09,46.67 224.09,45.43 223.6,44.93 U$15.33
N$26
  Top 0.152: U$15.34 222.8,44.93 223.36,45.5 RN8.7
N$27  (via drill 0.25 pad 0.51)
  Top 0.152: v222.55,45.8 v222.56,45.8 RN8.6 | v223.6,34.16 U$15.22
  Bottom 0.152: v223.6,34.16 223.6,44.76 v222.55,45.8
N$28
  Top 0.152: U$15.35 222,44.91 221.76,45.14 RN8.5
N$29
  Top 0.152: U$15.36 221.2,46.76 220.78,47.18 R12.2
N$30
  Top 0.203: U$7.1 284.1,81.69 C54.1
N$31
  Top 0.152: 288.98,76.52 U$8.C
  Top 0.508: U$7.8 281.81,74.57 284.1,74.57 C54.2 288.98,76.52 294.67,76.52 L2.1
N$32  (via drill 0.25 pad 0.51)
  Top 0.152: R32.1 v275.77,77.65 | v275.77,79.98 R31.2
  Top 0.203: U$7.4 277.28,80.96 R31.2
  Bottom 0.152: v275.77,77.65 v275.77,79.98
N$33
  Top 0.203: U$9.1 283.87,57.56 C88.1
N$34
  Top 0.152: 289.05,52.26 U$13.C | C88.2 283.87,51.41
  Top 0.508: U$9.8 282.04,50.8 283.87,50.8 C88.2 289.05,52.26 289.05,51.46 294.69,51.46 L3.1
N$35  (via drill 0.25 pad 0.51)
  Top 0.152: 275.92,53.76 R34.1
  Top 0.203: v275.89,56.34 275.89,57.29 R33.2 277.99,57.32 U$9.4 | v275.89,54.81 275.89,53.76 R34.1
  Bottom 0.203: v275.89,56.34 v275.89,54.81
N$36
  Top 0.152: U$15.37 220.4,45.31 219.99,45.72 218.19,45.72 217.78,46.13 R15.2
N$37  (via drill 0.25 pad 0.51)
  Top 0.152: v181.13,61.19 R16.2 | v207.75,51.71 216.38,51.71 216.79,51.31 216.79,46.2 217.58,45.41 219.18,45.41 219.6,44.99 U$15.38
  Bottom 0.152: v207.75,51.71 207.75,54.23 206.15,55.83 203.76,55.83 200.58,59 200.58,59.59 198.98,61.19 v181.13,61.19
N$38
  Top 0.152: U$15.19 221.23,32.95 R42.2
N$39
  Top 0.152: U$15.18 220.4,29.64 219.98,29.22 R67.2
N$40  (via drill 0.25 pad 0.51)
  Top 0.152: v159.03,30.28 159.03,35.48 160.63,37.08 R68.2 | v202.64,13.64 201.63,12.62 159.66,12.62 v159.03,11.99 | v219.66,31.73 219.66,32.4 219.6,32.46 U$15.17
  Bottom 0.152: v159.03,11.99 v159.03,30.28 | v219.66,31.73 219.66,15.24 218.06,13.64 v202.64,13.64
N$41  (via drill 0.25 pad 0.51)
  Top 0.152: v199.85,25.98 R69.2 | v218.69,31.73 218.8,31.83 U$15.16
  Bottom 0.152: v218.69,31.73 218.69,27.28 217.09,25.68 208.97,25.68 207.85,26.8 200.66,26.8 v199.85,25.98
N$42  (via drill 0.25 pad 0.51)
  Top 0.152: v202.34,46.51 202.34,42.98 203.94,41.38 217.98,41.38 218.8,42.19 U$15.39 | v162.51,33.33 162.5,33.34 R70.2
  Bottom 0.152: v162.51,33.33 164.49,35.31 168.68,35.31 169.49,36.12 169.49,36.68 172.68,39.86 175.82,39.86 178.99,43.03 178.99,56.34 180.59,57.94 197.69,57.94 199.29,56.34 199.29,54.29 202.34,51.24 v202.34,46.51
N$43  (via drill 0.25 pad 0.51)
  Top 0.152: v219.18,30.68 218.41,30.68 218,31.1 U$15.15 | v160.91,15.21 v202.36,15.21 | v160.91,29.97 160.91,31.32 161.72,32.13 R71.2
  Bottom 0.152: v202.36,15.21 218.36,15.21 219.18,16.03 v219.18,30.68 | v160.91,29.97 v160.91,15.21
N$44  (via drill 0.25 pad 0.51)
  Top 0.152: v222.78,34.16 222.8,34.15 U$15.21 | v204.67,57.89 204.67,58.34 183.46,58.34 183.26,58.55 R72.2
  Bottom 0.152: v204.67,57.89 212.6,57.89 218.95,51.54 218.95,38 v222.78,34.16
N$45
  Top 0.152: U$15.7 211.6,31.6 210.8,30.8 RN4.4
N$46
  Top 0.152: U$15.5 RN4.3
N$47
  Top 0.152: U$15.4 RN4.2
N$48
  Top 0.152: U$15.2 207.6,31.6 208.4,30.79 RN4.1
N$49
  Top 0.152: U$15.13 216.4,31.91 215.22,30.73 RN3.4
N$50
  Top 0.152: RN3.3 214.42,30.51 214.8,30.88 U$15.11
N$51
  Top 0.152: RN3.2 213.62,30.51 214,30.88 U$15.10
N$52
  Top 0.152: RN3.1 212.82,30.51 212.4,30.93 U$15.8
N$53
  Top 0.152: U$15.42 216.4,44.91 215.55,45.75 RN2.1
N$54
  Top 0.152: U$15.44 214.75,43.86 RN2.2
N$55
  Top 0.152: U$15.45 213.95,43.86 RN2.3
N$56
  Top 0.152: U$15.47 212.4,44.91 213.15,45.66 RN2.4
N$57
  Top 0.152: U$15.53 207.6,45.21 208,45.62 208.2,45.62 208.43,45.84 RN1.4
N$58
  Top 0.152: U$15.51 209.23,43.86 RN1.3
N$59
  Top 0.152: U$15.50 210.03,43.86 RN1.2
N$60
  Top 0.152: U$15.48 211.6,44.91 210.83,45.68 RN1.1
N$61
  Top 0.254: U$1.1 258.76,73.86 257.95,74.68 D1.A
  Top 0.305: U$1.1 259.82,72.45 259.82,73.05 261.9,73.05 U$2.2
N$62  (via drill 0.25 pad 0.51)
  Top 0.152: v218.47,34.16 221.82,34.16 222,33.99 U$15.20 | v207.14,56.64 204.48,59.3 R73.2
  Bottom 0.152: v207.14,56.64 212.12,56.64 218.47,50.29 v218.47,34.16
N$68
  Top 0.152: U$3.7 195.42,66.62 R27.2
N$69
  Top 0.152: U$4.7 R17.2
N$70
  Top 0.152: U$5.7 R18.2
N$71
  Top 0.152: U$6.7 225.54,66.73 R19.2
N$72
  Top 0.152: C53.1 195.42,78.35 X1.1 | C53.1 197.64,74.62 198.04,74.22 C52.2 | C53.1 195.4,74.62 U$3.2
N$73  (via drill 0.25 pad 0.51)
  Top 0.152: X1.2 193.35,74.78 193.5,74.62 C53.2 194.13,74.62 U$3.3 | v191.44,76.07 C48.2
  Bottom 0.152: X1.2 193.35,77.98 v191.44,76.07
N$74  (via drill 0.25 pad 0.51)
  Top 0.152: C21.2 207.19,74.5 206.78,74.91 v205.31,74.91 C19.1 204.47,74.91 U$4.2
  Bottom 0.152: v205.31,74.91 205.25,74.96 X2.1
N$75  (via drill 0.25 pad 0.51)
  Top 0.152: 203.2,74.91 v201.75,74.91 200.86,74.91 200.66,74.7 C20.2 | 203.2,74.91 U$4.3 | 203.2,74.91 C19.2
  Bottom 0.152: v201.75,74.91 X2.2
N$76
  Top 0.152: C22.1 216.17,77.11 216.35,77.3 X3.1 | C22.1 218.44,74.8 218.85,74.4 C60.2 | C22.1 216.17,73.47 216.18,73.46 U$5.2
N$77  (via drill 0.25 pad 0.51)
  Top 0.152: C23.2 212.37,74.98 v212.88,75.49 214.87,75.49 C22.2 214.91,74.8 U$5.3
  Bottom 0.152: v212.88,75.49 212.85,75.51 X3.2
N$78
  Top 0.152: 225.53,74.73 224.84,74.73 X4.1 | 225.53,74.73 U$6.2 | 225.53,74.73 C61.1 227.84,74.73 228.24,74.32 C63.2
N$79  (via drill 0.25 pad 0.51)
  Top 0.152: C62.2 v221.89,75.41 224.24,75.41 C61.2 224.26,74.73 U$6.3
  Bottom 0.152: v221.89,75.41 221.34,75.97 X4.2
N$80
  Top 0.61: J5.1 291.54,28.6 U$11.4
N$81
  Top 0.152: R53.2 242.24,8.57 T4.B R52.2
N$82
  Bottom 0.61: J4.2 295.17,41.99 295.17,32.23 J5.2
N$84
  Top 0.152: 258.87,23.44 T6.B | 258.87,23.44 257.52,23.44 R20.2 | 258.87,23.44 C27.2
N$85
  Top 0.152: R62.2 254.81,21.65 U$10.8
N$86
  Top 0.152: R63.2 256.79,21.65 256.79,24.89 256.84,24.95 U$10.10
N$87
  Top 0.61: J4.1 289.31,38.02 289.31,45.34 F1.2
N$88
  Top 0.152: R20.1 255.83,23.52 U$10.9
N$89
  Top 0.203: R40.1 257.66,34.9 256.84,34.09 U$10.1
N$90
  Top 0.152: 255.83,39.38 T7.B | 255.83,39.38 R64.2 | 255.83,39.38 R44.1
N$91
  Top 0.152: JP3.1 T4.C
N$92  (via drill 0.25 pad 0.51)
  Top 0.254: U$12.4 279.45,35.94 266.13,35.94 R40.2
  Top 0.61: v277.65,40.84 279.45,40.84 279.45,35.94
  Bottom 0.61: v277.65,40.84 277.65,41.78 265.18,41.78 265.18,45.31 F1.1
N$93  (via drill 0.25 pad 0.51)
  Top 0.508: U$12.3 v270.92,33.66 | U$11.3 v270.92,26.31 270.92,27.74 U$14.3
  Bottom 0.508: v270.92,33.66 v270.92,26.31
N$94  (via drill 0.25 pad 0.51)
  Top 0.152: U$11.1 273.05,30.88 273.46,31.29 | v272.87,37.31
  Top 0.254: 273.46,31.29 v274.37,31.29 | v272.87,37.31 U$12.1
  Top 0.508: U$11.1 269.85,30.88 269.85,30.28 U$14.4
  Bottom 0.254: v272.87,37.31 274.37,35.81 v274.37,31.29
N$95
  Top 0.152: T6.C 259.82,27.74
  Top 0.203: 259.82,27.74 U$14.2
N$96
  Top 0.152: U$14.1 262.15,30.29
  Top 0.203: 262.15,30.29 R25.1
N$97
  Top 0.152: U$10.3 254.81,33.98 254.61,34.19 254,34.19 253.8,33.98 U$10.4
N$98
  Top 0.152: D2.A 242.32,21.36
  Top 0.305: 242.32,21.36 U$16.2 | U$17.1 242.45,23.56 D2.A
N$99
  Top 0.152: IC1.2 249.14,17.28 C37.+ | IC1.2 249.14,25.71 247.54,27.3 R47.2 | 248.83,24.06 IC1.2 | D2.C 246.25,23.22 246.08,23.38 C30.1
  Top 0.203: D2.C 247.24,21.49 248.26,22.5 248.26,24.06 IC1.2
N$100
  Top 0.152: U$10.7 TP28.TP
N$101
  Top 0.152: R26.1 R47.1 244.16,25.88 243.74,25.46 U$17.3
N$102
  Top 0.152: R55.2 233.47,31.3 T5.B R54.2
N$103
  Top 0.152: JP2.1 238.46,30.48 238.43,30.51 T5.C
  Bottom 0.152: JP2.1 238.68,30.48 238.48,30.68 238.48,47.88 238.68,48.08 SV3.2
N$104
  Top 0.152: SV3.1 R56.2
N$105
  Top 0.152: SV3.3 R57.2
N$106
  Top 0.152: SV3.4 242.82,43 242.85,42.98 R58.1 251.85,40.34 T7.C
N$107
  Top 0.152: JP2.2 R22.2
N$108  (via drill 0.25 pad 0.51)
  Top 0.152: 198.84,11.35 T3.B | v199.69,11.35 198.84,11.35 | 198.84,11.35 R30.2 | v199.69,13.59 R28.1
  Bottom 0.152: v199.69,11.35 v199.69,13.59
N$109
  Top 0.152: LED2.C R29.1
N$110
  Top 0.152: T3.C R29.2
N$112
  Top 0.152: 240.43,65.38 239.24,65.38 239.03,65.16 R43.1 | 240.43,65.38 T1.B | 240.43,65.38 C45.2 240.58,63.22 R35.2
N$113
  Top 0.152: SG1.- 237.57,71.2 239.16,69.6 T1.C
N$114  (via drill 0.25 pad 0.51)
  Top 0.152: v164.64,70.69 R48.2 | v164.52,80.24 U$19.P7 | v163.47,82.14 162.79,82.14 RN11.8
  Bottom 0.152: v164.64,70.69 164.52,70.81 v164.52,80.24 163.88,80.24 163.47,80.64 v163.47,82.14
N$115  (via drill 0.25 pad 0.51)
  Top 0.152: v162.48,70.69 R49.2 | v163.14,78.03 v163.15,78.04 U$19.P5 | v161.98,81.74 161.99,81.76 RN11.7
  Bottom 0.152: v162.48,70.69 162.48,77.37 v163.14,78.03 163.14,80.57 v161.98,81.74
N$116  (via drill 0.25 pad 0.51)
  Top 0.152: v160.27,70.69 R50.2 | RN11.6 161.19,76.5 v161.85,75.84 U$19.P3
  Bottom 0.152: v161.85,75.84 160.27,74.27 v160.27,70.69
N$117  (via drill 0.25 pad 0.51)
  Top 0.152: v87.48,11.63 v87.47,11.64 RN12.8 | v82.7,6.45 J1.8
  Bottom 0.152: v82.7,6.45 84.3,6.45 87.48,9.63 v87.48,11.63
N$118
  Top 0.152: J1.6 83.7,8.99 84.11,9.4 87.48,9.4 89.07,10.99 RN12.6
N$119
  Top 0.152: RN12.5 89.87,10.69 88.27,9.09 84.61,9.09 84.2,8.69 J1.5
N$120
  Top 0.152: U$17.4 239.24,25.46 238.75,24.97 236.55,24.97 236.14,24.56 236.14,20.14 237.74,18.54 R46.2
N$123
  Top 0.152: J1.7 83.2,9.3 83.61,9.7 86.66,9.7 88.27,11.31 RN12.7
N$124
  Top 0.152: RN13.5 86.14,11.66 85.32,10.85 83.69,10.85 82.88,10.03 82.88,9.37 82.2,8.7 J1.9
N$125  (via drill 0.25 pad 0.51)
  Top 0.152: v85.34,11.63 v85.34,11.64 RN13.6 | v81.71,8.48 81.7,8.48 J1.10
  Bottom 0.152: v81.71,8.48 82.19,8.48 v85.34,11.63
N$126  (via drill 0.25 pad 0.51)
  Top 0.152: v81.23,9.14 81.2,9.12 J1.11 | v84.53,11.63 v84.54,11.64 RN13.7
  Bottom 0.152: v84.53,11.63 82.04,9.14 v81.23,9.14
N$127  (via drill 0.25 pad 0.51)
  Top 0.152: v83.72,11.63 83.74,11.65 RN13.8 | v80.7,8.48 80.7,8.48 J1.12
  Bottom 0.152: v80.7,8.48 80.7,10.03 82.3,11.63 v83.72,11.63
N$128
  Top 0.152: J1.13 80.2,9.63 82.38,11.8 RN14.5
N$129
  Top 0.152: J1.14 79.7,9.93 81.58,11.81 RN14.6
N$130
  Top 0.152: J1.15 79.2,10.24 80.78,11.81 RN14.7
N$131
  Top 0.152: J1.16 78.7,10.54 79.98,11.82 RN14.8
N$132
  Top 0.152: J1.17 78.2,10.62 78.62,11.03 RN15.5
N$133
  Top 0.152: J1.18 77.7,10.72 77.82,10.83 RN15.6
N$134
  Top 0.152: J1.19 77.2,9.86 77.02,10.04 RN15.7
N$135
  Top 0.152: J1.20 76.7,11.25 76.22,11.74 RN15.8
N$136
  Top 0.152: J1.21 76.2,10.44 74.86,11.78 RN16.5
N$137
  Top 0.152: J1.22 75.7,9.3 74.06,10.94 RN16.6
N$138  (via drill 0.25 pad 0.51)
  Top 0.152: v73.28,11.63 73.26,11.65 RN16.7 | v75.21,8.48 v75.2,8.48 J1.23
  Bottom 0.152: v75.21,8.48 75.21,10.82 74.4,11.63 v73.28,11.63
N$139  (via drill 0.25 pad 0.51)
  Top 0.152: v71.78,12.04 72.46,12.04 RN16.8 | v74.7,6.45 J1.24
  Bottom 0.152: v74.7,6.45 74.7,9.12 v71.78,12.04
N$140
  Top 0.152: RN17.5 71.08,11.43 72.68,9.83 73.41,9.83 74.2,9.03 J1.25
N$141  (via drill 0.25 pad 0.51)
  Top 0.152: v70.43,11.63 70.43,12.24 70.28,12.39 RN17.6 | v72.69,6.45 73.53,6.45 73.7,6.62 J1.26
  Bottom 0.152: v72.69,6.45 72.69,9.37 v70.43,11.63
N$142
  Top 0.152: J1.27 73.2,8.71 72.39,9.53 71.07,9.53 69.48,11.12 RN17.7
N$143
  Top 0.152: J1.28 72.7,8.41 71.89,9.22 70.28,9.22 68.68,10.83 RN17.8
N$144
  Top 0.152: RN18.5 67.27,10.52 68.87,8.91 71.5,8.91 71.7,8.71 J1.30
N$145
  Top 0.152: J1.31 71.2,8.41 71,8.61 68.07,8.61 66.47,10.22 RN18.6
N$146
  Top 0.152: J1.32 70.7,8.31 67.26,8.31 65.67,9.9 RN18.7
N$147  (via drill 0.25 pad 0.51)
  Top 0.152: v64.85,11.63 64.87,11.65 RN18.8 | v70.21,6.45 v70.2,6.45 J1.33
  Bottom 0.152: v70.21,6.45 69.12,7.54 68.94,7.54 v64.85,11.63
N$148
  Top 0.152: J3.3 41.72,18.85 41.89,19.01 R51.2
N$149
  Top 0.152: J3.4 40.72,14.3 40.39,14.64 R65.2
N$150  (via drill 0.25 pad 0.51)
  Top 0.152: v174.32,28.35 174.48,28.19 U1.6
  Bottom 0.152: v174.32,28.35 174.32,23.09 171.15,19.91 167.51,19.91 164.34,23.09 164.34,29.64 162.74,31.24 156.03,31.24 155.63,30.84 155.63,12.01 149.28,5.66 139.24,5.66 JP4.2
N$151
  Top 0.152: JP4.3 110.69,4.06 BT1.1
N$153
  Top 0.152: C24.2 164.01,18.82 Q1.2 165.43,18.48 165.95,19 R13.2
N$154
  Top 0.152: C25.2 164.01,16.31 Q1.1 166.57,16.58 166.76,16.38 R74.2
NRST  (via drill 0.25 pad 0.51)
  Top 0.152: 160.74,8.71 S1.2 160.74,3.12 158.96,1.35 41.91,1.35 38.73,4.53 38.73,6.27 J3.6 | v156.39,30.76 156.09,31.05 R9.1 | 160.74,8.71 160.43,9.02 159.02,9.02 C5.1 | 160.74,8.71 161.04,9.02 v163.73,9.02 | v186.82,28.35 186.98,28.19 U1.31
  Bottom 0.152: 165.28,18.92 164.85,18.92 164.03,19.74 164.03,29.16 162.43,30.76 v156.39,30.76 | 165.28,18.92 163.73,17.37 v163.73,9.02 | v186.82,28.35 185.24,29.92 177.98,29.92 174.8,26.75 174.8,22.1 171.63,18.92 165.28,18.92
PA0
  Top 0.152: U1.40 191.48,25.73 191.46,25.71 TP29.TP
PA1
  Top 0.152: TP30.TP 191.98,25.18 U1.41
PA7
  Top 0.152: TP19.TP U1.53
PA9
  Top 0.152: TP21.TP 177.98,53.9 | 177.98,53.9 | 177.98,53.9 U1.120
PB2
  Top 0.152: TP22.TP 196.67,35.51 196.66,35.53 U1.58
PB5
  Top 0.152: TP23.TP 167.78,35.53 U1.163
PC0
  Top 0.152: TP1.TP U1.32
PC1  (via drill 0.25 pad 0.51)
  Top 0.152: v187.48,28.35 187.72,28.35 187.98,28.09 U1.33 | v187.48,23.47 187.73,23.47 187.99,23.72 TP2.TP
  Bottom 0.152: v187.48,23.47 v187.48,28.35
PC2
  Top 0.152: TP5.TP 188.48,25.18 U1.34
PC4  (via drill 0.25 pad 0.51)
  Top 0.152: v198.93,34.24 TP3.TP | v197.23,33.53 U1.54
  Bottom 0.152: v197.23,33.53 198.22,33.53 v198.93,34.24
PC5
  Top 0.152: TP10.TP 196.67,34.04 196.66,34.03 U1.55
PC7
  Top 0.152: TP17.TP 179.98,54.96 U1.116
PC8
  Top 0.152: TP16.TP 179.5,55.17 179.48,55.15 U1.117
PD2
  Top 0.152: TP24.TP 167.83,45.03 U1.144
PD3  (via drill 0.25 pad 0.51)
  Top 0.152: v165.84,44.5 166.52,44.5 TP25.TP | v171.3,44.53 | v171.3,44.53 U1.145
  Bottom 0.152: v171.3,44.53 171.27,44.5 v165.84,44.5
PD4
  Top 0.152: TP31.TP 167.78,44.03 U1.146
PD5
  Top 0.152: TP32.TP 166.59,43.52 168.28,43.52 168.29,43.53 U1.147
PD6
  Top 0.152: TP11.TP 167.78,42.03 U1.150
PD7  (1 unrouted)
  Top 0.152: TP12.TP 166.59,41.48 168.28,41.48 168.32,41.53 U1.151
PDR_ON
  Top 0.152: R10.2 164.95,29.97 164.95,30.71 165.77,31.53 U1.171
PF8
  Top 0.152: U1.26 184.48,25.71 183.87,25.1 183.87,24.77 TP33.TP
PF9
  Top 0.152: U1.27 184.96,27.05 TP34.TP
PG10
  Top 0.152: TP35.TP 167.78,40.53 U1.153
PH1
  Top 0.152: TP47.TP 186.61,25.71 186.48,25.84 U1.30
PH4
  Top 0.152: TP36.TP U1.45
PI3
  Top 0.152: TP40.TP 167.83,50.03 U1.134
PI8
  Top 0.152: TP41.TP U1.7
PI11
  Top 0.152: TP45.TP U1.13
POWER_LED  (via drill 0.25 pad 0.51)
  Top 0.152: v189.99,25.71 189.18,25.71 188.98,25.91 U1.35 | v196.14,13.59 R28.2
  Bottom 0.152: v196.14,13.59 194.69,13.59 193.88,14.4 193.88,24.11 192.28,25.71 v189.99,25.71
PWM_CPUFAN
  Top 0.152: U1.24 183.48,23.22 185.08,21.62 229.39,21.62 240.56,10.44 R52.1
PWM_HEATER  (via drill 0.25 pad 0.51)
  Top 0.152: v183.46,28.35 183.72,28.35 183.98,28.09 U1.25 | v194.36,26.19 195.53,25.02 221.64,25.02 223.24,26.62 223.24,28.07 224.05,28.88 228.42,28.88 230.03,30.48 230.03,31.85 230.43,32.26 230.78,32.26 232.38,33.86 232.38,34.47 232.6,34.68 R54.1
  Bottom 0.152: v194.36,26.19 189.56,26.19 187.96,24.59 187.96,23.19 187.76,22.99 186.64,22.99 183.46,26.16 v183.46,28.35
SCK  (via drill 0.25 pad 0.51)
  Top 0.152: v162.48,47.52 v162.49,47.53 U1.139 | v162.48,67.13 R49.1
  Bottom 0.152: v162.48,67.13 v162.48,47.52
SDCKE1
  Top 0.152: U1.84 196.57,48.53 196.57,49.45 198.17,51.05 206.1,51.05 207.24,52.2 216.97,52.2 217.78,51.38 R15.1
SDCLK  (via drill 0.25 pad 0.51)
  Top 0.152: v181.13,56.67 R16.1 | v181.97,53.8 181.98,53.79 U1.112
  Bottom 0.152: v181.97,53.8 181.97,55.83 v181.13,56.67
SDI  (via drill 0.25 pad 0.51)
  Top 0.152: v164.64,67.13 R48.1 | v168.71,47.02 168.72,47.03 U1.140
  Bottom 0.152: v168.71,47.02 164.64,51.08 v164.64,67.13
SDNCAS
  Top 0.152: R68.1 167.07,37.03 U1.160
SDNE1  (via drill 0.25 pad 0.51)
  Top 0.152: v216.31,50.75 198.48,50.75 196.88,49.15 196.88,48.23 196.67,48.03 U1.83 | v217.22,28.3 221.23,28.3 R42.1
  Bottom 0.152: v217.22,28.3 217.22,49.84 v216.31,50.75
SDNRAS  (via drill 0.25 pad 0.51)
  Top 0.152: v196.75,36.02 196.74,36.03 U1.59 | v203.73,36.02 203.73,26.49 204.55,25.68 218.26,25.68 219.08,26.49 R67.1
  Bottom 0.152: v203.73,36.02 v196.75,36.02
SDNWE
  Top 0.152: R69.1 196.36,27.13 195.95,27.53 195.15,27.53 194.34,28.35 194.34,29.53 U1.46
SDO  (via drill 0.25 pad 0.51)
  Top 0.152: v160.76,46.71 160.94,46.53 U1.141 | v160.27,67.13 R50.1
  Bottom 0.152: v160.27,67.13 160.76,66.65 v160.76,46.71
TCK
  Top 0.152: R7.1 155.07,42.7 154.91,42.85 154.91,48.11 155.33,48.53 U1.137
TDI
  Top 0.152: R3.1 155.87,48.03 U1.138
TDO  (via drill 0.25 pad 0.51)
  Top 0.152: v168.07,36.52 v168.07,36.53 U1.161 | v167.06,38.99 156.46,38.99 156.04,38.57 R8.1
  Bottom 0.152: v167.06,38.99 168.07,37.97 v168.07,36.52
TMS  (via drill 0.25 pad 0.51)
  Top 0.152: v156.79,45.16 R4.1 | v156.79,54.23 156.85,54.28 175.77,54.28 175.98,54.07 U1.124
  Bottom 0.152: v156.79,54.23 v156.79,45.16
TP_SCL
  Top 0.152: R51.1 R36.1 41.61,22.57 41.2,22.16 41.2,19.96 41,19.76 39.83,19.76 39.01,20.57 39.01,25.83 40.01,26.82 157.91,26.82 159.51,28.42 159.51,33.78 161.11,35.38 166.19,35.38 166.57,35.01 170,35.01 U1.164
TP_SDA  (via drill 0.25 pad 0.51)
  Top 0.152: R65.1 40.41,20.71 R41.1 39.62,22.57 39.62,25.15 40.21,25.73 121.41,25.73 121.59,25.91 165.48,25.91 v165.53,25.86 | v167.79,34.52 v167.8,34.53 U1.165
  Bottom 0.152: v167.79,34.52 165.53,32.26 v165.53,25.86
TRST  (via drill 0.25 pad 0.51)
  Top 0.152: v158.55,50.32 R1.1 | v168.71,36.02 169.33,36.02 169.34,36.03 U1.162
  Bottom 0.152: v168.71,36.02 164.9,36.02 158.55,42.37 v158.55,50.32
TS_ADDR0  (via drill 0.25 pad 0.51)
  Top 0.152: v205.41,54.41 208.99,54.41 209.79,55.2 IC2.1 | v194.16,46.02 v194.16,46.03 U1.79
  Bottom 0.152: v194.16,46.02 203.81,46.02 205.41,47.62 v205.41,54.41
TS_ADDR1  (via drill 0.25 pad 0.51)
  Top 0.152: v196.75,45.54 196.75,46.36 196.58,46.53 U1.80 | v209.27,55.37 209.27,56.92 209.47,57.12 210.44,57.12 IC2.2
  Bottom 0.152: v209.27,55.37 209.27,48.72 206.1,45.54 v196.75,45.54
TS_ADDR2  (via drill 0.25 pad 0.51)
  Top 0.152: v196.77,53.92 210.29,53.92 211.09,54.73 IC2.3 | v194.95,54.89 192.79,54.89 191.98,54.08 U1.92
  Bottom 0.152: v194.95,54.89 196.37,54.89 196.77,54.48 v196.77,53.92
TS_EN  (via drill 0.25 pad 0.51)
  Top 0.152: v176.45,34.85 174.63,33.03 U1.168 | v186.97,57.45 187.66,56.77 193.83,56.77 195.43,55.17 195.43,53.85 195.83,53.44 211.43,53.44 213.04,55.05 IC2.6
  Bottom 0.152: v186.97,57.45 180.9,57.45 179.3,55.86 179.3,37.69 v176.45,34.85
TS_SCK  (via drill 0.25 pad 0.51)
  Top 0.152: U$3.5 192.86,67.87 197.87,67.87 200.08,65.66 v200.89,65.66 201.93,65.66 U$4.5 | U$5.5 214.2,66.73 214.2,67.77 214.4,67.97 v218.26,67.97 218.64,67.97 219.89,66.73 U$6.5 | v202.9,60.1 182.63,60.1 182.22,59.69 182.22,56.72 183.03,55.91 191.26,55.91 191.48,55.69 U1.93
  Bottom 0.152: v218.26,67.97 202.23,67.97 201.63,67.36 | 201.63,67.36 200.89,66.62 v200.89,65.66 | 201.63,67.36 201.93,67.06 201.93,65.33 202.9,64.36 v202.9,60.1
TS_SDI  (via drill 0.25 pad 0.51)
  Top 0.152: R19.1 227.24,63.45 218.1,63.45 217.89,63.65 R18.1 217.82,64.47 217.82,63.63 v210.13,63.63 | R27.1 200.66,64.41 201.42,63.65 206.18,63.65 R17.1 v207.11,64.54 | v189.66,55.42 189.79,55.55 190.88,55.55 191.08,55.35 191.08,53.73 190.98,53.62 U1.94 | v203.38,57.25 v189.66,57.25
  Bottom 0.152: v189.66,57.25 v189.66,55.42 | v203.38,57.25 203.38,62.94 204.98,64.54 v207.11,64.54 209.22,64.54 v210.13,63.63
TS_SDO
  Top 0.152: TP46.TP 190.48,54.94 U1.95
USART2_RX  (via drill 0.25 pad 0.51)
  Top 0.152: SV5.2 R24.2 | v197.38,27.84 198.32,28.78 198.32,29.62 197.91,30.03 U1.47
  Bottom 0.152: SV5.2 181.05,8.76 182.65,10.36 196.57,10.36 197.38,11.18 v197.38,27.84
USART2_TX  (via drill 0.25 pad 0.51)  (1 unrouted)
  Top 0.152: v192.53,24.66 192.53,25.68 192.48,25.73 U1.42 | v178.51,7.62 R23.2
  Bottom 0.152: SV5.1 v178.51,7.62 178.51,8.36 184.87,14.72 190.4,14.72 193.57,17.89 193.57,23.62 v192.53,24.66
USB_DM  (via drill 0.25 pad 0.51)
  Top 0.152: v176.99,71.63 160.02,71.63 159.82,71.83 159.82,71.91 153.45,78.27 X5.2 | v176.99,53.8 v176.98,53.79 U1.122
  Bottom 0.152: v176.99,53.8 v176.99,71.63
USB_DP  (via drill 0.25 pad 0.51)
  Top 0.152: v152.17,77.32 151.56,77.32 151.41,77.47 X5.3 | v151.16,54.71 176.07,54.71 176.48,54.31 U1.123
  Bottom 0.152: v151.16,54.71 151.16,76.3 v152.17,77.32
USB_ID  (via drill 0.25 pad 0.51)
  Top 0.152: v175.97,68.81 159.59,68.81 159.18,69.22 159.18,70.31 152.82,76.67 X5.4 | v177.44,51.21 177.48,51.24 U1.121
  Bottom 0.152: v177.44,51.21 175.97,52.68 v175.97,68.81

## Text on the board
tPlace: **DNP** | 4.7uf | 4.7uf | + | + | + | B550 | - | - | + | - | - | 10k | 5.6uH | 0.1uF | RT8289 | 10uF | FB / (100R / @100Mhz) | 0R | *OVEN* | *PCB* | 0.01uF | 0.01uF | 0.01uF | MBR0530 | 10-22uH | .01uf | *USB* | 0.01uF | 0.01uF | BUZZER | 0.01uF | 2.0k | FAN5333B | .01uf | 4.7uf | 4.7uf | 5.6k | 0.01uF | 0.01uF | 0.01uF | 0.01uF | 0.01uF | 0.01uF | MAX31855 | 120k | MAX31855 | MAX31855 | MAX31855 | *1A OR >* | POWER LEDS | 1.0uF | 0.1uF | 0.1uF | NPN | 100R | 10uF | 10uF | 10uF | 10uF | 4.7k | 10uF | 68R | 68R | 68R | 0.1uF | 0.1uF | 3V3 | *MICROSD* | DNP | 20R | 20R | 20R | 20R | 3V3_TP | 5V0 | 390R | 5V0_TP | 240R | 10k | 2.2uf | 33R | 33R | 33R | 74HC138 | CS6 | 4.7uf | 4.7uf | 10k | 4.7uf | CS5 | 1.0uH | 0.1uF | B550 | 0.1uF | CS4 | 5.6uH | PC8 | CS7 | 4.7uf | FB / (100R / @100Mhz) | PD12 | .01uF | 10uF | RT8289 | PA9 | PC7 | PG3 | TS_SDO | PD13 | PD11 | 2.2uf | .1uF | LEDS | 0R | 4.7uf | 4.7uf | * | .01uf | 3.16k | .01uf | STLINK/JTAG | PI3 | 0R | 33R | 33R | 20R | 33R | 33R | 33R | 330R | 120VAC IN | 20R | 20R | PD2 | PD3 | 330R | 10k | 20R | PD5 | PD4 | PD6 | STM32H7 | 0.1uF | 10uF | 10k | PD7 | NPN | 1.5A - 5x20mm | PG10 | 64MB SDRAM | PG13 | N-FET | 20R | 0.1uF | HEATER | 33R | *1M - 400V* | PB5 | PB2 | 1k | 10k | 1k | 20R | PC5 | 33R | PC4 | 100R | PA7 | DAC1_OUT2 | 33R | * | 100R | * | 10k | FL5160 | * | PH4 | 2.0k | VOM1271 | 33R | 33R | 33R | 10k | NPN | 80k | 33R | 33R | FAN5333B | NPN | 4.7k | 4.7k | * | PA1 | 33R | 12V REG | PE2 | PI8 | PC2 | 10uF | N-FET | COOL FAN | PE3 | PE6 | PI11 | PF9 | PH1 | PC0 | PA0 | 1.0uF | 1k | 22nF | PF8 | PC1 | LOPWR | 470uF | ** ML2032 ONLY ** | RTC CLOCK | PE4 | 10-22uH | MBR0530 | 0.1uF | *1A OR >* | 33R | 1.5pF | 0R | 4k7 | 1k | 1k | 33R | 33R | 0R | 68R | 32.768Khz | 0R | *DNP* | 4.7uF | 10uF | 68R | 68R | 68R | 68R | 68R | 1.5pF | POWER LED | .01uF | 470uF | 470uF | .01uF | 4.7k | 68R | 2k | 24MHZ CLOCK | 1.0uH | 24Mhz | RESET | BOOT | RS232 | 10k | 1k | CPU FAN | 4.7k | 50R | 9VAC IN | 0.1uF | 10k | 4.7k | NPN | *1 | 240R | .01uF | 0.1uF | *1 | *1 | 10uF | BATTERY | .01uF | 10k | NPN | FLASH | ROM | TX | RX | GND | 3V3 | T962A CONTROLLER V3.3 | ON | OFF