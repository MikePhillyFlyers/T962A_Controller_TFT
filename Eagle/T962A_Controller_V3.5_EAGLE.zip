# EAGLE board T962A_Controller_V3.5 (EAGLE 7.7.0), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
GND  (via drill 0.25 pad 0.51, 4.06 pad 6.6)  (2 unrouted) (continued)
  Bottom 0.152: 138.38,10.01 135.64,10.01 | 135.64,10.01 129.34,10.01 | 129.34,10.01 122.81,10.01 | 122.81,10.01 116.66,10.01 | 204.17,71.88 201.45,71.88 201.14,72.19 v200.66,72.19 197.26,72.19 v196.67,71.6 195.4,71.6 | 194.51,53.42 194.51,52.12 194.82,51.82 | v254.08,70.46 255.52,70.46 255.83,70.76 | 194.51,53.42 194.82,53.72 195.94,53.72 v195.94,54.66 | v243.26,65.63 243.23,65.61 v243.23,63.48 242.11,62.36 v242.11,59.46 238.46,59.46 v237.31,60.6 | 209.88,15.98 v204.14,15.98 204.14,17.12 v204.06,17.2 | 209.88,15.98 215.98,15.98 | 215.98,15.98 v217.96,15.98 | 194.51,53.42 194.51,53.52 194.31,53.72 193.55,53.72 193.14,53.31 v193.14,51.46 | v250.09,20.22 252.58,17.73 C37.- 256.49,16.64 v257.2,15.93 257.12,15.85 v257.12,10.79 259.66,10.79 v262.41,8.05 261.44,7.09 v261.44,2.67 | 195.4,71.6 192.48,71.6 192.38,71.5 v191.44,71.5 191.44,69.77 v191.39,69.72 | v215.6,42.11 v215.6,37.74 v215.6,34.42 v211.86,34.42 v211.86,35.38 | v171.4,42.11 v172.57,42.11 175.97,45.52 v175.97,49.78 v176.63,49.78 176.63,50.7 176.23,51.1 175.9,51.1 174.24,52.76 174.24,60.83 174.7,61.29 v174.7,62.61 v174.7,83.97 175.82,83.97 v179.55,80.24 180.75,79.05 v180.75,74.27 | v42.72,10.82 42.16,11.38 28.55,11.38 28.55,17.57 U2.39 | 222.1,60.63 v222.1,59.11 222.1,57.94 220.5,56.34 v219.63,56.34 219.63,55.32 v222.66,52.3 | 222.1,60.63 221.46,60.63 221.06,61.04 v221.06,61.77 | 38.35,28.45 38.66,28.75 v47.65,28.75 47.65,27.74 47.35,27.43 v47.35,16.31 47.35,15.14 v50.29,12.19 50.29,8.97 49.99,8.66 | 215.54,10.14 215.85,10.44 222.15,10.44 225.73,6.86 v229.62,6.86 229.62,10.03 229.92,10.34 | v241.12,81.41 241.63,80.9 v241.63,73.74 239.09,71.2 238.15,71.2
  Bottom 0.152: v210.21,73.3 209.07,74.45 v209.07,79.96 209.07,81.89 208.94,82.02 v208.94,83.85 | v263.17,24.64 263.17,23.77 v260.15,20.75 | v57.79,4.47 57.79,4.95 54.61,8.13 v53.8,8.13 50.52,8.13 49.99,8.66 | v257.96,29.97 259.44,29.97 v262.43,32.97 262.43,36.45 v260.58,38.3 | v235.99,28.35 233.55,25.91 233.55,23.88 | v253.77,83.77 v260.27,83.77 v260.27,78.66 v260.27,77.19 | v248.18,72.34 250.16,70.36 v250.16,67.89 251.38,66.68 v253.49,66.68 256.9,66.68 | v241.73,40.95 241.73,36.35 v240.84,35.46 | v171.4,73.43 170.05,73.43 169.95,73.33 v167.26,73.33 167.26,72.62 167.69,72.19 v167.69,70.43 168.2,69.93 v168.2,66.35 168.2,64.47 C38.- | v247.78,5.87 247.78,10.11 v246.89,11 246.89,13.66 246.71,13.84 v246.71,16.71 | v155.02,83.24 155.02,82.12 v157.33,79.81 157.33,77.37 v158.37,76.33 | v186.94,73.91 187.58,74.55 v187.58,78.97 187.58,81.71 v186.69,82.6 | v218.92,79.83 220.14,78.61 v220.14,75.39 220.14,72.34 | v226.8,71.7 228.7,71.7 v230.56,73.56 232.36,73.56 232.66,73.86 | 229.92,10.34 234.19,10.34 v234.67,10.82 234.67,14.68 234.98,14.99 | 13.49,7.14 13.49,1.93 10.31,1.93 JP6.1 | 231.62,51.89 234.82,51.89 v235.99,53.06 | v232.38,83.11 232.38,79.25 232.66,78.97 v232.66,77.93 232.66,73.86 | v261.39,51.13 261.39,54.28 v260.25,55.42 259.74,55.93 C11.- | 234.98,14.99 239.09,14.99 v239.57,15.47 | v204.17,5.54 203.15,6.55 v203.15,9.88 203.71,10.44 v210.72,10.44 215.24,10.44 215.54,10.14 | v234.44,41.2 232.33,43.31 v232.33,44.42 232.33,45.85 231.62,46.56 | 38.35,28.45 38.05,28.75 28.8,28.75 28.8,29.08 C64.2 | C11.- 251.16,55.93 | 238.15,71.2 237.85,71.5 v233.58,71.5 233.58,72.95 232.66,73.86
  Bottom 0.152: v215.54,5.87 215.54,10.14 | v163.8,42.67 162.33,42.67 v160.81,44.2 | 251.16,55.93 250.85,56.24 v250.85,60.25 | v186.77,67.92 186.77,66.6 186.49,66.32 v186.49,63.91 | v154.46,61.87 157.1,61.87 157.53,61.44 v158.12,61.44 | 129.34,10.01 v129.34,5.97 | 116.66,10.01 v116.66,6.02 | 251.16,55.93 251.16,55.02 v249.5,53.37 | v259.69,61.34 258.57,62.46 256.9,62.46 | 49.99,8.66 v46.41,8.66 | 231.62,51.89 v228.17,51.89 | v249.91,34.85 250.75,35.69 v250.75,38.12 250.75,38.76 249.94,39.57 v248.89,39.57 248.89,41.35 v249.4,41.86 | v230.38,23.57 233.25,23.57 233.55,23.88 | 238.15,71.2 v238.15,68.38 | 229.92,10.34 229.62,10.64 v227,10.64 | 233.55,23.88 234.34,23.09 234.34,21.49 v233.55,20.7 231.34,18.49 v231.34,15.37 234.59,15.37 234.98,14.99 | 255.75,47.37 v253.19,47.37 | 231.62,54.18 229.87,54.18 v227.86,56.19 | 209.88,15.98 v209.88,18.06 | 98.76,11.56 v98.76,13.56 | v222.17,12.8 222.17,15.77 v224.13,17.73 | 71.73,6.2 71.73,4.77 v71.81,4.7 | 215.98,15.98 v215.98,17.88 | 140.67,10.01 v140.67,11.73 | 135.64,10.01 v135.64,11.68 | 225.27,72.34 v225.27,70.69 | 78.33,6.2 v78.33,4.6 | v222.1,61.42 222.1,60.63 | 83.72,6.2 v83.72,4.67 | 195.4,71.6 v195.4,70.51 | 228.14,61.42 228.14,61.67 228.4,61.93 v228.63,61.93 | 256.9,62.46 v255.96,62.46 | 122.81,10.01 v122.81,10.44 | 204.17,71.88 v204.17,71.07 | 215.98,71.55 v215.98,70.79 | 138.38,10.01 v138.38,9.47 | 228.42,40.97 v228.8,40.97 | 13.49,7.14 18.49,7.14 19.3,7.95 U2.38 17.99,9.81 17.99,19.18 19.3,20.5 | 38.35,28.45 38.35,24.23 38.15,24.03 U2.15 31.52,24.03 26.89,19.41 | 26.89,19.41 U2.39 | v31.48,15.94 30.38,17.04 29.07,17.04 U2.39 | 19.3,20.5 U2.1 19.3,26.44 v16,26.44 | 19.3,20.5 20.4,19.41
  Bottom 0.152: 13.49,7.14 10.8,7.14 v6.38,11.56 | 20.4,19.41 26.89,19.41 | 19.3,20.5 17.4,20.5 v17.4,21.23 | 20.4,19.41 20.4,17.25 v22.38,17.25
  Bottom 0.406: v257.81,65.3 257.81,65.23 v260.02,65.23
  other vias: 231.95,50.04 250.42,27.33 262.76,17.42 189.26,8.36 231.65,35.53 36.47,11.3 174.62,70.48 255.96,51.64 33.2,23.55 33.15,19.18 33.38,15.39 15.39,11.89 12.9,15.82 13.61,25.15 24.03,14.96 27.79,13.11 38.13,28.45 30.35,29.01 35.61,28.96 24.59,23.44 28.63,23.42 3.68,18.77 8.25,17.32 15.37,3.17 22.2,3.23
  pour Bottom (isolate 0.508): 0,0 0,30.35 141,30.35 141,86.11 263.93,86.11 263.93,0
  pour Top (isolate 0.508): 0,0 0,30.35 141,30.35 141,86.11 263.93,86.11 263.93,0
LCD_ADJ  (via drill 0.25 pad 0.51)
  Top 0.152: U$1.4 256.86,68.22 R37.2 256.55,65.56 253.38,62.38 248.97,62.38 242.62,56.03 242.62,55.3 235.85,48.52 235.85,40.23 232.67,37.06 201.5,37.06 199.9,35.46 v199.9,32.79 | v196.75,32.79 196.74,32.78 U1.52
  Bottom 0.152: v196.75,32.79 v199.9,32.79
LCD_B0  (via drill 0.25 pad 0.51)
  Top 0.152: v76.1,19.13 74.86,17.89 RN16.4 | v76.1,27.86 157.1,27.86 157.91,28.67 157.91,37.16 159.51,38.76 170,38.76 U1.157
  Bottom 0.152: v76.1,27.86 v76.1,19.13
LCD_B1  (via drill 0.25 pad 0.51)
  Top 0.152: v155.14,31.14 155.14,39.01 155.96,39.83 168.28,39.83 168.32,39.78 U1.155 | v155.14,18.52 88.57,18.52 86.97,16.92 86.97,14.02 86.56,13.61 74.27,13.61 74.06,13.82 RN16.3
  Bottom 0.152: v155.14,18.52 v155.14,31.14
LCD_B2  (via drill 0.25 pad 0.51)
  Top 0.152: v142.39,55.3 142.9,55.8 178.56,55.8 178.98,55.39 U1.118 | v76.58,20.22 74.85,20.22 73.26,18.62 RN16.2
  Bottom 0.152: v76.58,20.22 76.58,25.17 79.76,28.35 141.58,28.35 142.39,29.16 v142.39,55.3
LCD_B3  (via drill 0.25 pad 0.51)
  Top 0.152: v148.92,25.5 75.64,25.5 72.46,22.32 RN16.1 | v148.92,40.26 169.32,40.26 169.34,40.28 U1.154
  Bottom 0.152: v148.92,40.26 v148.92,25.5
LCD_B4  (via drill 0.25 pad 0.51)
  Top 0.152: v71.78,14.55 71.78,15.06 71.58,15.27 71.08,15.27 RN17.4 | v161.75,17.25 161.7,17.3 114.15,17.3 v113.51,16.66 | v161.75,27.99 164.8,27.99 166.4,29.59 166.4,29.97 167.2,30.78 U1.173
  Bottom 0.152: v113.51,16.66 87.1,16.66 84.99,14.55 v71.78,14.55 | v161.75,27.99 v161.75,17.25
LCD_B5  (via drill 0.25 pad 0.51)
  Top 0.152: v71.73,17.86 71.73,16.61 70.92,15.8 70.69,15.8 70.28,15.39 RN17.3 | v71.73,26.59 166.12,26.59 167.72,28.2 167.72,29.46 168.54,30.28 U1.174
  Bottom 0.152: v71.73,26.59 v71.73,17.86
LCD_B6  (via drill 0.25 pad 0.51)
  Top 0.152: v71.25,17.37 69.48,15.6 RN17.2 | v156.54,28.35 75.72,28.35 74.93,27.56 v71.25,27.56 | v156.54,25.02 166.98,25.02 168.58,26.62 168.58,29.57 168.79,29.78 U1.175
  Bottom 0.152: v71.25,27.56 v71.25,17.37 | v156.54,25.02 v156.54,28.35
LCD_B7  (via drill 0.25 pad 0.51)
  Top 0.152: v78.31,24.36 78.49,24.54 167.28,24.54 168.88,26.14 168.88,29.28 U1.176 | v68.68,15.44 RN17.1
  Bottom 0.152: v68.68,15.44 77.5,15.44 78.31,16.26 v78.31,24.36
LCD_CLK  (via drill 0.25 pad 0.51)
  Top 0.152: v68.68,16.56 68.2,16.08 67.27,16.08 RN6.8 | v67.13,13.69 67.13,14.32 67.27,14.45 RN18.4 | v141.83,57.73 142.49,57.07 179.83,57.07 180.04,56.87 180.04,56.01 180.24,55.8 181.66,55.8 182.48,54.99 U1.111
  Bottom 0.152: v67.13,13.69 67.13,15.67 68.02,16.56 v68.68,16.56 68.68,26.52 71.86,29.69 141.43,29.69 141.83,30.1 v141.83,57.73
LCD_DE  (via drill 0.25 pad 0.51)
  Top 0.152: 69.72,3.48 69.42,3.17 63.63,3.17 62.81,3.99 62.81,14.9 R38.1 | 69.72,3.48 69.72,7.35 69.7,7.37 J1.34 | v158.17,3.5 157.38,2.72 105.05,2.72 103.94,3.83 95.05,3.83 94.39,3.17 70.03,3.17 69.72,3.48 | v185.45,28.6 185.45,28 185.48,27.96 U1.28
  Bottom 0.152: v158.17,3.5 171.93,3.5 175.11,6.68 175.11,26.7 178.28,29.87 184.18,29.87 v185.45,28.6
LCD_G0
  Top 0.152: RN14.4 82.38,21.18 82.78,21.59 170.71,21.59 171.12,22 171.12,29.01 172.72,30.61 176.28,30.61 179.46,33.8 179.46,34.47 180.28,35.28 U1.57
LCD_G1  (via drill 0.25 pad 0.51)
  Top 0.152: v170.59,22.45 170.03,21.89 81.99,21.89 81.58,21.48 RN14.3 | v181.23,33.3 192.24,33.3 193.72,34.78 U1.56
  Bottom 0.152: v181.23,33.3 174.02,33.3 170.84,30.12 170.84,22.71 v170.59,22.45
LCD_G2  (via drill 0.25 pad 0.51)
  Top 0.152: v152.65,53.9 159.82,53.9 160.1,54.18 173.76,54.18 173.98,53.96 U1.128 | v152.65,22.76 81.58,22.76 80.78,21.95 RN14.2
  Bottom 0.152: v152.65,22.76 v152.65,53.9
LCD_G3  (via drill 0.25 pad 0.51)
  Top 0.152: v152.12,53.24 168.07,53.24 168.71,53.87 173.48,53.87 U1.129 | v83.31,21.11 v152.12,21.11 | v79.98,15.44 RN14.1
  Bottom 0.152: v152.12,21.11 v152.12,53.24 | v79.98,15.44 83.32,18.78 83.32,21.1 v83.31,21.11
LCD_G4  (via drill 0.25 pad 0.51)
  Top 0.152: v149.4,51.64 149.58,51.82 168.86,51.82 169.52,51.16 172.77,51.16 172.98,51.36 U1.130 | v149.4,23.72 81,23.72 79.4,22.12 79.4,16.94 78.62,16.16 RN15.4
  Bottom 0.152: v149.4,23.72 v149.4,51.64
LCD_G5  (via drill 0.25 pad 0.51)
  Top 0.152: v76.71,17.5 77.42,17.5 77.82,17.1 RN15.3 | v74.22,28.68 141.4,28.68 142.99,30.27 142.99,51.31 143.81,52.12 169.82,52.12 170.48,51.46 172.31,51.46 172.48,51.62 U1.131
  Bottom 0.152: v74.22,28.68 74.22,19.99 v76.71,17.5
LCD_G6  (via drill 0.25 pad 0.51)
  Top 0.152: v73.13,28.27 74.55,29.69 141.58,29.69 141.99,30.1 141.99,52.58 143.59,54.18 148.56,54.18 149.99,52.76 U1.132 | v77.22,17.02 77.02,16.82 RN15.2
  Bottom 0.152: v77.22,17.02 76.3,17.02 73.13,20.19 v73.13,28.27
LCD_G7  (via drill 0.25 pad 0.51)
  Top 0.152: v150.24,24.05 150.09,24.21 80.7,24.21 79.1,22.61 79.1,21.19 76.22,18.32 RN15.1 | v150.24,51.33 150.27,51.36 168.31,51.36 168.88,50.78 U1.133
  Bottom 0.152: v150.24,51.33 v150.24,24.05
LCD_HSYNC  (via drill 0.25 pad 0.51)
  Top 0.152: RN6.6 RN18.2 65.67,13.84 65.46,13.64 v64.39,13.64 | v175.9,17.14 194.51,17.14 195.33,17.96 195.33,18.49 195.12,18.69 180.49,18.69 178.89,20.29 178.89,23.27 177.29,24.87 177.29,25.86 177.48,26.04 U1.12
  Bottom 0.152: v64.39,13.64 60.3,9.55 60.3,2.36 61.11,1.55 172.72,1.55 175.9,4.72 v175.9,17.14
LCD_LED+  (via drill 0.25 pad 0.51)
  Top 0.152: C15.1 v244.17,70.03 | C41.1 100.45,4.74 99.95,5.23 C40.+ 97.21,6.45 86.11,6.45 85.7,6.85 J1.2
  Top 0.203: D1.C 251.32,73.44 R45.2 C15.1
  Bottom 0.152: C40.+ 108.97,5.23 111.48,2.72 172.24,2.72 175.41,5.89 175.41,20.6 176.23,21.41 177.52,21.41 177.52,4.5 178.33,3.68 231.47,3.68 244.17,16.38 v244.17,70.03
LCD_LED_FB
  Top 0.152: R45.1 253.02,72.31 253.16,72.17 R61.1 255.04,71.87 256.86,71.87 U$1.3
LCD_R0  (via drill 0.25 pad 0.51)
  Top 0.152: v198.68,16.71 202.36,16.71 203.17,15.9 203.17,15.34 202.77,14.93 160.43,14.93 160.27,15.09 89.87,15.09 RN12.4 | v192.99,28.6 192.98,28.59 U1.43
  Bottom 0.152: v192.99,28.6 197.87,28.6 198.68,27.79 v198.68,16.71
LCD_R1  (via drill 0.25 pad 0.51)
  Top 0.152: v194.84,18.21 194.36,17.73 90.68,17.73 89.07,16.12 RN12.3 | RN12.3 | v194.84,27.3 U1.44
  Bottom 0.152: v194.84,27.3 v194.84,18.21
LCD_R2  (via drill 0.25 pad 0.51)
  Top 0.152: v192.13,34.49 181.56,34.49 180.75,33.68 180.75,33.48 177.57,30.3 173.02,30.3 171.42,28.7 171.42,20.85 170.61,20.04 160.27,20.04 159.87,19.63 159.87,18.44 159.46,18.03 89.87,18.03 88.27,16.44 RN12.2 | v194.16,49.12 194.31,49.28 U1.85
  Bottom 0.152: v194.16,49.12 192.81,47.78 192.81,35.18 v192.13,34.49
LCD_R3  (via drill 0.25 pad 0.51)
  Top 0.152: v195.33,14.33 101.12,14.33 100.31,13.52 100.31,11.2 97.13,8.03 92.28,8.03 90.68,9.63 90.68,13.06 89.87,13.87 87.47,13.87 RN12.1 | v192.33,37.31 v189.18,37.31 | v193.27,49.61 193.44,49.78 U1.86
  Bottom 0.152: v189.18,37.31 189.18,29.39 190.78,27.79 195.12,27.79 195.33,27.58 v195.33,14.33 | v193.27,49.61 192.41,48.74 192.41,37.39 v192.33,37.31
LCD_R4  (via drill 0.25 pad 0.51)
  Top 0.152: v171.91,48.49 191.01,48.49 192.8,50.28 U1.87 | v151.64,19.18 87.73,19.18 86.14,17.58 RN13.4
  Bottom 0.152: v151.64,19.18 151.64,54.15 152.45,54.97 157.1,54.97 160.27,51.79 160.27,46.69 160.48,46.48 169.9,46.48 v171.91,48.49
LCD_R5  (via drill 0.25 pad 0.51)
  Top 0.152: v195.45,51.33 U1.88 | v172.57,39.09 v191.92,39.09 | v169.8,20.65 154.76,20.65 153.77,19.66 86.94,19.66 85.34,18.05 RN13.3
  Bottom 0.152: v191.92,39.09 191.92,49.28 192.74,50.09 195.05,50.09 195.45,50.49 v195.45,51.33 | v169.8,20.65 169.8,36.32 v172.57,39.09
LCD_R6  (via drill 0.25 pad 0.51)
  Top 0.152: v84.56,15.44 84.56,14.7 84.54,14.68 RN13.2 | v178.44,59.23 178.23,59.44 v142.98,59.44 | v206.2,52.12 206.02,52.3 198.12,52.3 197.66,52.76 U1.89
  Bottom 0.152: v142.98,59.44 142.98,28.57 142.16,27.76 90.91,27.76 84.56,21.41 v84.56,15.44 | v206.2,52.12 206.2,54.79 205.79,55.19 203.15,55.19 199.97,58.37 199.97,58.42 199.16,59.23 v178.44,59.23
LCD_R7  (via drill 0.25 pad 0.51)
  Top 0.152: v176.15,50.44 182.17,50.44 182.98,51.25 U1.110 | v152.45,20.14 85.34,20.14 83.74,18.54 RN13.1
  Bottom 0.152: v152.45,20.14 153.14,20.83 153.14,34.19 157.58,38.63 157.58,50.55 158.39,51.36 159.16,51.36 159.97,50.55 159.97,46.38 160.17,46.18 171.83,46.18 173.43,47.78 173.43,50.72 174.24,51.54 175.34,50.44 v176.15,50.44
LCD_STBY  (via drill 0.25 pad 0.51)
  Top 0.152: 66.47,15.39 RN18.3 | v67.95,15.39 66.47,15.39 | 66.47,15.39 RN6.7 | v143.48,38.94 146.84,38.94 148.64,40.74 166.78,40.74 167.36,41.33 168.28,41.33 168.32,41.28 U1.152
  Bottom 0.152: v67.95,15.39 69.29,14.05 87.48,14.05 88.93,15.49 136.93,15.49 143.28,21.84 143.28,38.73 v143.48,38.94
LCD_VSYNC  (via drill 0.25 pad 0.51)
  Top 0.152: RN18.1 RN6.5 61.75,16.09 60.93,15.28 60.93,4.9 62.04,3.79 62.04,3.68 62.85,2.87 96.95,2.87 97.61,3.53 99.26,3.53 100.46,2.34 v101.52,2.34 | v167.72,18.21 175.74,18.21 177.34,19.81 177.34,24.05 176.98,24.42 U1.11 | v161.54,2.24 v161.54,4.04
  Bottom 0.152: v161.54,4.04 166.9,4.04 167.72,4.85 v167.72,18.21 | v101.52,2.34 161.44,2.34 v161.54,2.24
MCO1  (via drill 0.25 pad 0.51)  (1 unrouted)
  Top 0.152: v173.63,28.6 173.48,28.44 U1.4 | v180.21,51.46 178.64,51.46 178.48,51.62 U1.119
  Bottom 0.152: v180.21,51.46 180.21,45.59 182.17,43.64 182.17,33.45 180.57,31.85 174.45,31.85 173.63,31.04 v173.63,28.6
N$1  (via drill 0.25 pad 0.51)
  Top 0.152: L4.2 207.67,15.98 C4.1 206.74,15.98 C2.1 206.74,19.37 v206.73,19.38 | v206.73,23.42 191.03,23.42 190.63,23.82 190.63,24.77 190.98,25.12 U1.39
  Bottom 0.152: v206.73,19.38 v206.73,23.42
N$2
  Top 0.152: SV1.3 145.42,49.66 154.14,49.66 R1.2
N$3
  Top 0.152: SV1.5 145.67,46.86 153.95,46.86 154.17,47.08 R3.2
N$4
  Top 0.152: LED1.C R2.1
N$5
  Top 0.152: SV1.7 145.42,46.56 153.95,46.56 154.17,46.34 R4.2
N$6
  Top 0.152: LED5.C R5.2
N$7
  Top 0.152: SV1.9 145.42,44.02 153.92,44.02 154.14,43.8 R7.2
N$9
  Top 0.152: SV1.13 145.67,36.7 154.13,36.7 154.34,36.92 R8.2
N$10
  Top 0.152: SV1.15 145.42,36.4 154.18,36.4 154.39,36.18 R9.2
N$12  (via drill 0.25 pad 0.51)
  Top 0.152: v169.09,7.52 R11.1
  Bottom 0.152: v169.09,7.52 169.04,7.47 JP1.2
N$13  (via drill 0.25 pad 0.51)
  Top 0.152: R59.1 R60.2 197.78,18.82 197.01,19.58 v191.82,19.58 | v189.51,25.32 190.07,25.32 190.48,25.73 U1.38
  Bottom 0.152: v189.51,25.32 191.83,23.01 v191.83,19.59 v191.82,19.58
N$14  (via drill 0.25 pad 0.51)
  Top 0.152: v196.75,47.27 196.74,47.28 U1.81 | v197.26,55.63 C10.1
  Bottom 0.152: v197.26,55.63 197.26,47.78 v196.75,47.27
N$15  (via drill 0.25 pad 0.51)
  Top 0.152: v175.01,57.66 C9.1 | v175.49,54.05 175.48,54.04 U1.125
  Bottom 0.152: v175.49,54.05 175.01,54.53 v175.01,57.66
N$16
  Top 0.152: U$15.23 RN5.8
N$17
  Top 0.152: U$15.26 RN5.5
N$18
  Top 0.152: U$15.25 RN5.6
N$19
  Top 0.152: U$15.24 RN5.7
N$20  (via drill 0.25 pad 0.51)
  Top 0.152: v228.45,45.16 226.8,45.16 U$15.29 | v228.63,46.94 228.61,46.93 RN7.8
  Bottom 0.152: v228.63,46.94 228.63,45.34 v228.45,45.16
N$21  (via drill 0.25 pad 0.51)
  Top 0.152: 193.68,42.78 193.37,42.48 193.37,38.09 193.68,37.78 | 193.68,37.78 v193.68,36.17 v184.05,36.17 179.57,36.17 177.97,34.57 177.97,34.47 174.78,31.28 U1.172 166.37,31.28 165.57,30.48 165.57,30.07 163.97,28.47 160.73,28.47 v160.38,28.12 | C39.+ 220.24,53.39 194.92,53.39 194.11,54.2 v192.79,54.2 192.79,53.87 192.48,53.87 U1.91 | v182.78,49.12 v174.32,49.12 173,49.12 172.85,49.28 U1.136 165.2,49.28 v163.8,50.67 | 193.68,37.78 U1.62 | L8.2 231.14,58.42 230.84,58.12 v230.84,57.53 C29.1 | v230.78,54.89 C26.1 | 193.68,42.78 193.37,43.09 193.37,46.96 194.19,47.78 U1.82 | U1.36 189.48,28.68 189.08,29.08 v188.26,29.08 183.18,29.08 182.98,28.88 U1.23 v182.98,26.01 | U1.159 171.77,37.78 172.09,38.1 v172.09,42.62 171.28,42.62 171.12,42.78 U1.149 | v174.32,50.75 174.48,50.91 U1.127 | 193.68,42.78 193.7,42.78 | 193.7,42.78 | 193.7,42.78 U1.72 | v180.92,51.46 180.92,52.04 180.98,52.09 U1.114 | v196.75,31.29 196.74,31.28 U1.49 | v186.49,56.72 191.69,56.72 v192.79,55.63 | v178.99,29.08 178.99,27.98 178.98,27.96 U1.15 | v186.49,54.05 v186.48,54.04 U1.103
  Bottom 0.152: v188.26,29.08 188.26,31.95 v184.05,36.17 184.05,47.85 v182.78,49.12 182.78,51.16 182.47,51.46 | 182.47,51.46 182.47,57 182.88,57.4 185.8,57.4 v186.49,56.72 v186.49,54.05 | v174.32,50.75 v174.32,49.12 174.32,44.86 v172.09,42.62 | C39.+ 229.49,58.88 v230.84,57.53 230.84,54.94 v230.78,54.89 | 182.47,51.46 v180.92,51.46 | v193.68,36.17 193.68,31.7 194.08,31.29 v196.75,31.29 | v192.79,54.2 v192.79,55.63 | v160.38,28.12 160.38,10.67 154.03,4.32 JP4.1 | v163.8,50.67 C38.+ | v182.98,26.01 179.91,29.08 v178.99,29.08
N$22
  Top 0.152: RN7.7 227.15,46.05 227.55,45.64 228.73,45.64 228.93,45.44 228.93,43.18 228.52,42.77 226.21,42.77 226,42.99 U$15.30
N$23
  Top 0.152: U$15.31 225.2,45.16 225.93,45.16 226.35,45.57 RN7.6
N$24
  Top 0.152: U$15.32 224.4,45.26 224.6,45.47 225.15,45.47 225.55,45.87 RN7.5
N$25
  Top 0.152: RN8.8 224.09,46.93 224.09,45.68 223.6,45.19 U$15.33
N$26
  Top 0.152: U$15.34 222.8,45.19 223.36,45.75 RN8.7
N$27  (via drill 0.25 pad 0.51)
  Top 0.152: v222.55,46.05 v222.56,46.06 RN8.6 | v223.6,34.42 U$15.22
  Bottom 0.152: v223.6,34.42 223.6,45.01 v222.55,46.05
N$28
  Top 0.152: U$15.35 222,45.16 221.76,45.39 RN8.5
N$29
  Top 0.152: U$15.36 221.2,47.02 220.78,47.44 R12.2
N$30
  Top 0.203: U$7.1 284.1,81.94 C54.1
N$31
  Top 0.152: 288.98,76.77 U$8.C
  Top 0.508: U$7.8 281.81,74.83 284.1,74.83 C54.2 288.98,76.77 294.67,76.77 L2.1
N$32  (via drill 0.25 pad 0.51)
  Top 0.152: R32.1 v275.77,77.9 | v275.77,80.24 R31.2
  Top 0.203: U$7.4 277.28,81.22 R31.2
  Bottom 0.152: v275.77,77.9 v275.77,80.24
N$33
  Top 0.203: U$9.1 283.87,57.81 C88.1
N$34
  Top 0.152: 289.05,52.52 U$13.C | C88.2 283.87,51.66
  Top 0.508: U$9.8 282.04,51.05 283.87,51.05 C88.2 289.05,52.52 289.05,51.71 294.69,51.71 L3.1
N$35  (via drill 0.25 pad 0.51)
  Top 0.152: 275.92,54.01 R34.1
  Top 0.203: v275.89,56.59 275.89,57.55 R33.2 277.99,57.57 U$9.4 | v275.89,55.07 275.89,54.01 R34.1
  Bottom 0.203: v275.89,56.59 v275.89,55.07
N$36
  Top 0.152: U$15.37 220.4,45.57 219.99,45.97 218.19,45.97 217.78,46.38 R15.2
N$37  (via drill 0.25 pad 0.51)
  Top 0.152: v181.13,61.44 R16.2 | v207.75,51.97 216.38,51.97 216.79,51.56 216.79,46.46 217.58,45.66 219.18,45.66 219.6,45.24 U$15.38
  Bottom 0.152: v207.75,51.97 207.75,54.48 206.15,56.08 203.76,56.08 200.58,59.26 200.58,59.84 198.98,61.44 v181.13,61.44
N$38
  Top 0.152: U$15.19 221.23,33.21 R42.2
N$39
  Top 0.152: U$15.18 220.4,29.9 219.98,29.48 R67.2
N$40  (via drill 0.25 pad 0.51)
  Top 0.152: v159.03,30.53 159.03,35.74 160.63,37.34 R68.2 | v202.64,13.89 201.63,12.88 159.66,12.88 v159.03,12.24 | v219.66,31.98 219.66,32.65 219.6,32.71 U$15.17
  Bottom 0.152: v159.03,12.24 v159.03,30.53 | v219.66,31.98 219.66,15.49 218.06,13.89 v202.64,13.89
N$41  (via drill 0.25 pad 0.51)
  Top 0.152: v199.85,26.24 R69.2 | v218.69,31.98 218.8,32.08 U$15.16
  Bottom 0.152: v218.69,31.98 218.69,27.53 217.09,25.93 208.97,25.93 207.85,27.05 200.66,27.05 v199.85,26.24
N$42  (via drill 0.25 pad 0.51)
  Top 0.152: v202.34,46.76 202.34,43.23 203.94,41.63 217.98,41.63 218.8,42.44 U$15.39 | v162.51,33.58 162.5,33.59 R70.2
  Bottom 0.152: v162.51,33.58 164.49,35.56 168.68,35.56 169.49,36.37 169.49,36.93 172.68,40.11 175.82,40.11 178.99,43.29 178.99,56.59 180.59,58.19 197.69,58.19 199.29,56.59 199.29,54.54 202.34,51.49 v202.34,46.76
N$43  (via drill 0.25 pad 0.51)
  Top 0.152: v219.18,30.94 218.41,30.94 218,31.36 U$15.15 | v160.91,15.47 v202.36,15.47 | v160.91,30.23 160.91,31.57 161.72,32.38 R71.2
  Bottom 0.152: v202.36,15.47 218.36,15.47 219.18,16.28 v219.18,30.94 | v160.91,30.23 v160.91,15.47
N$44  (via drill 0.25 pad 0.51)
  Top 0.152: v222.78,34.42 222.8,34.41 U$15.21 | v204.67,58.14 v204.67,58.15 204.67,58.6 183.46,58.6 183.26,58.8 R72.2
  Bottom 0.152: v204.67,58.14 212.6,58.14 218.95,51.79 218.95,38.25 v222.78,34.42
N$45
  Top 0.152: U$15.7 211.6,31.85 210.8,31.06 RN4.4
N$46
  Top 0.152: U$15.5 RN4.3
N$47
  Top 0.152: U$15.4 RN4.2
N$48
  Top 0.152: U$15.2 207.6,31.85 208.4,31.05 RN4.1
N$49
  Top 0.152: U$15.13 216.4,32.16 215.22,30.99 RN3.4
N$50
  Top 0.152: RN3.3 214.42,30.76 214.8,31.13 U$15.11
N$51
  Top 0.152: RN3.2 213.62,30.76 214,31.13 U$15.10
N$52
  Top 0.152: RN3.1 212.82,30.76 212.4,31.18 U$15.8
N$53
  Top 0.152: U$15.42 216.4,45.16 215.55,46.01 RN2.1
N$54
  Top 0.152: U$15.44 214.75,44.11 RN2.2
N$55
  Top 0.152: U$15.45 213.95,44.11 RN2.3
N$56
  Top 0.152: U$15.47 212.4,45.16 213.15,45.92 RN2.4
N$57
  Top 0.152: U$15.53 207.6,45.47 208,45.87 208.2,45.87 208.43,46.09 RN1.4
N$58
  Top 0.152: U$15.51 209.23,44.11 RN1.3
N$59
  Top 0.152: U$15.50 210.03,44.11 RN1.2
N$60
  Top 0.152: U$15.48 211.6,45.16 210.83,45.93 RN1.1
N$61
  Top 0.254: U$1.1 258.76,74.12 257.95,74.93 D1.A
  Top 0.305: U$1.1 259.82,72.7 259.82,73.3 261.9,73.3 U$2.2
N$62  (via drill 0.25 pad 0.51)
  Top 0.152: v218.47,34.42 221.82,34.42 222,34.24 U$15.20 | v207.14,56.9 204.48,59.55 R73.2
  Bottom 0.152: v207.14,56.9 212.12,56.9 218.47,50.55 v218.47,34.42
N$68
  Top 0.152: U$3.7 195.42,66.88 R27.2
N$69
  Top 0.152: U$4.7 R17.2
N$70
  Top 0.152: U$5.7 R18.2
N$71
  Top 0.152: U$6.7 225.54,66.98 R19.2
N$72
  Top 0.152: C53.1 195.42,78.6 X1.1 | C53.1 197.64,74.88 198.04,74.47 C52.2 | C53.1 195.4,74.88 U$3.2
N$73  (via drill 0.25 pad 0.51)
  Top 0.152: X1.2 193.35,75.03 193.5,74.88 C53.2 194.13,74.88 U$3.3 | v191.44,76.33 C48.2
  Bottom 0.152: X1.2 193.35,78.23 v191.44,76.33
N$74  (via drill 0.25 pad 0.51)
  Top 0.152: C21.2 207.19,74.75 206.78,75.16 v205.31,75.16 C19.1 204.47,75.16 U$4.2
  Bottom 0.152: v205.31,75.16 205.25,75.21 X2.1
N$75  (via drill 0.25 pad 0.51)
  Top 0.152: 203.2,75.16 v201.75,75.16 200.86,75.16 200.66,74.96 C20.2 | 203.2,75.16 U$4.3 | 203.2,75.16 C19.2
  Bottom 0.152: v201.75,75.16 X2.2
N$76
  Top 0.152: C22.1 216.17,77.37 216.35,77.55 X3.1 | C22.1 218.44,75.06 218.85,74.65 C60.2 | C22.1 216.17,73.72 216.18,73.71 U$5.2
N$77  (via drill 0.25 pad 0.51)
  Top 0.152: C23.2 212.37,75.23 v212.88,75.74 214.87,75.74 C22.2 214.91,75.06 U$5.3
  Bottom 0.152: v212.88,75.74 212.85,75.77 X3.2
N$78
  Top 0.152: 225.53,74.98 224.84,74.98 X4.1 | 225.53,74.98 U$6.2 | 225.53,74.98 C61.1 227.84,74.98 228.24,74.57 C63.2
N$79  (via drill 0.25 pad 0.51)
  Top 0.152: C62.2 v221.89,75.67 224.24,75.67 C61.2 224.26,74.98 U$6.3
  Bottom 0.152: v221.89,75.67 221.34,76.22 X4.2
N$80
  Top 0.61: J5.1 291.54,28.85 U$11.4
N$81
  Top 0.152: R53.2 242.24,8.82 T4.B R52.2
N$82
  Bottom 0.61: J4.2 295.17,42.24 295.17,32.49 J5.2
N$84
  Top 0.152: 258.87,23.7 T6.B | 258.87,23.7 257.52,23.7 R20.2 | 258.87,23.7 C27.2
N$85
  Top 0.152: R62.2 254.81,21.91 U$10.8
N$86
  Top 0.152: R63.2 256.79,21.91 256.79,25.15 256.84,25.2 U$10.10
N$87
  Top 0.61: J4.1 289.31,38.28 289.31,45.59 F1.2
N$88
  Top 0.152: R20.1 255.83,23.77 U$10.9
N$89
  Top 0.203: R40.1 257.66,35.15 256.84,34.34 U$10.1
N$90
  Top 0.152: 255.83,39.64 T7.B | 255.83,39.64 R64.2 | 255.83,39.64 R44.1
N$91
  Top 0.152: JP3.1 T4.C
N$92  (via drill 0.25 pad 0.51)
  Top 0.254: U$12.4 279.45,36.2 266.13,36.2 R40.2
  Top 0.61: v277.65,41.1 279.45,41.1 279.45,36.2
  Bottom 0.61: v277.65,41.1 277.65,42.04 265.18,42.04 265.18,45.57 F1.1
N$93  (via drill 0.25 pad 0.51)
  Top 0.508: U$12.3 v270.92,33.91 | U$11.3 v270.92,26.57 270.92,27.99 U$14.3
  Bottom 0.508: v270.92,33.91 v270.92,26.57
N$94  (via drill 0.25 pad 0.51)
  Top 0.152: U$11.1 273.05,31.13 273.46,31.55 | v272.87,37.57
  Top 0.254: 273.46,31.55 v274.37,31.55 | v272.87,37.57 U$12.1
  Top 0.508: U$11.1 269.85,31.13 269.85,30.53 U$14.4
  Bottom 0.254: v272.87,37.57 274.37,36.07 v274.37,31.55
N$95
  Top 0.152: T6.C 259.82,27.99
  Top 0.203: 259.82,27.99 U$14.2
N$96
  Top 0.152: U$14.1 262.15,30.54
  Top 0.203: 262.15,30.54 R25.1
N$97
  Top 0.152: U$10.3 254.81,34.24 254.61,34.44 254,34.44 253.8,34.24 U$10.4
N$98
  Top 0.152: D2.A 242.32,21.61
  Top 0.305: 242.32,21.61 U$16.2 | U$17.1 242.45,23.81 D2.A
N$99
  Top 0.152: IC1.2 249.14,17.54 C37.+ | IC1.2 249.14,25.96 247.54,27.56 R47.2 | 248.83,24.32 IC1.2 | D2.C 246.25,23.47 246.08,23.64 C30.1
  Top 0.203: D2.C 247.24,21.74 248.26,22.76 248.26,24.32 IC1.2
N$100
  Top 0.152: U$10.7 TP28.TP
N$101
  Top 0.152: R26.1 R47.1 244.16,26.14 243.74,25.71 U$17.3
N$102
  Top 0.152: R55.2 233.47,31.56 T5.B R54.2
N$103
  Top 0.152: JP2.1 238.46,30.73 238.43,30.76 T5.C
  Bottom 0.152: JP2.1 238.68,30.73 238.48,30.94 238.48,48.13 238.68,48.34 SV3.2
N$104
  Top 0.152: SV3.1 R56.2
N$105
  Top 0.152: SV3.3 R57.2
N$106
  Top 0.152: SV3.4 242.82,43.26 242.85,43.23 R58.1 251.85,40.59 T7.C
N$107
  Top 0.152: JP2.2 R22.2
N$108  (via drill 0.25 pad 0.51)
  Top 0.152: 198.84,11.61 T3.B | v199.69,11.61 198.84,11.61 | 198.84,11.61 R30.2 | v199.69,13.84 R28.1
  Bottom 0.152: v199.69,11.61 v199.69,13.84
N$109
  Top 0.152: LED2.C R29.1
N$110
  Top 0.152: T3.C R29.2
N$112
  Top 0.152: 240.43,65.63 239.24,65.63 239.03,65.42 R43.1 | 240.43,65.63 T1.B | 240.43,65.63 C45.2 240.58,63.48 R35.2
N$113
  Top 0.152: SG1.- 237.57,71.45 239.16,69.86 T1.C
N$114  (via drill 0.25 pad 0.51)
  Top 0.152: v164.64,70.94 R48.2 | v164.52,80.49 U$19.P7 | v163.47,82.4 162.79,82.4 RN11.8
  Bottom 0.152: v164.64,70.94 164.52,71.07 v164.52,80.49 163.88,80.49 163.47,80.9 v163.47,82.4
N$115  (via drill 0.25 pad 0.51)
  Top 0.152: v162.48,70.94 R49.2 | v163.14,78.28 v163.15,78.29 U$19.P5 | v161.98,81.99 161.99,82.01 RN11.7
  Bottom 0.152: v162.48,70.94 162.48,77.62 v163.14,78.28 163.14,80.82 v161.98,81.99
N$116  (via drill 0.25 pad 0.51)
  Top 0.152: v160.27,70.94 R50.2 | RN11.6 161.19,76.75 v161.85,76.1 v161.85,76.09 U$19.P3
  Bottom 0.152: v161.85,76.1 160.27,74.52 v160.27,70.94
N$117  (via drill 0.25 pad 0.51)
  Top 0.152: v87.48,11.89 v87.47,11.89 RN12.8 | v82.7,6.71 J1.8
  Bottom 0.152: v82.7,6.71 84.3,6.71 87.48,9.88 v87.48,11.89
N$118
  Top 0.152: J1.6 83.7,9.25 84.11,9.65 87.48,9.65 89.07,11.25 RN12.6
N$119
  Top 0.152: RN12.5 89.87,10.95 88.27,9.35 84.61,9.35 84.2,8.94 J1.5
N$120
  Top 0.152: U$17.4 239.24,25.71 238.75,25.22 236.55,25.22 236.14,24.82 236.14,20.4 237.74,18.8 R46.2
N$123
  Top 0.152: J1.7 83.2,9.55 83.61,9.96 86.66,9.96 88.27,11.56 RN12.7
N$124
  Top 0.152: RN13.5 86.14,11.91 85.32,11.1 83.69,11.1 82.88,10.29 82.88,9.63 82.2,8.95 J1.9
N$125  (via drill 0.25 pad 0.51)
  Top 0.152: v85.34,11.89 RN13.6 | v81.71,8.74 81.7,8.73 J1.10
  Bottom 0.152: v81.71,8.74 82.19,8.74 v85.34,11.89
N$126  (via drill 0.25 pad 0.51)
  Top 0.152: v81.23,9.4 81.2,9.37 J1.11 | v84.53,11.89 v84.54,11.89 RN13.7
  Bottom 0.152: v84.53,11.89 82.04,9.4 v81.23,9.4
N$127  (via drill 0.25 pad 0.51)
  Top 0.152: v83.72,11.89 83.74,11.91 RN13.8 | v80.7,8.74 80.7,8.73 J1.12
  Bottom 0.152: v80.7,8.74 80.7,10.29 82.3,11.89 v83.72,11.89
N$128
  Top 0.152: J1.13 80.2,9.88 82.38,12.05 RN14.5
N$129
  Top 0.152: J1.14 79.7,10.18 81.58,12.06 RN14.6
N$130
  Top 0.152: J1.15 79.2,10.49 80.78,12.06 RN14.7
N$131
  Top 0.152: J1.16 78.7,10.79 79.98,12.07 RN14.8
N$132
  Top 0.152: J1.17 78.2,10.87 78.62,11.29 RN15.5
N$133
  Top 0.152: J1.18 77.7,10.97 77.82,11.09 RN15.6
N$134
  Top 0.152: J1.19 77.2,10.11 77.02,10.29 RN15.7
N$135
  Top 0.152: J1.20 76.7,11.51 76.22,11.99 RN15.8
N$136
  Top 0.152: J1.21 76.2,10.69 74.86,12.04 RN16.5
N$137
  Top 0.152: J1.22 75.7,9.55 74.06,11.19 RN16.6
N$138  (via drill 0.25 pad 0.51)
  Top 0.152: v73.28,11.89 73.26,11.91 RN16.7 | v75.21,8.74 v75.2,8.73 J1.23
  Bottom 0.152: v75.21,8.74 75.21,11.07 74.4,11.89 v73.28,11.89
N$139  (via drill 0.25 pad 0.51)
  Top 0.152: v71.78,12.29 72.46,12.29 RN16.8 | v74.7,6.71 J1.24
  Bottom 0.152: v74.7,6.71 74.7,9.37 v71.78,12.29
N$140
  Top 0.152: RN17.5 71.08,11.68 72.68,10.08 73.41,10.08 74.2,9.29 J1.25
N$141  (via drill 0.25 pad 0.51)
  Top 0.152: v70.43,11.89 70.43,12.49 70.28,12.65 RN17.6 | v72.69,6.71 73.53,6.71 73.7,6.88 J1.26
  Bottom 0.152: v72.69,6.71 72.69,9.63 v70.43,11.89
N$142
  Top 0.152: J1.27 73.2,8.97 72.39,9.78 71.07,9.78 69.48,11.37 RN17.7
N$143
  Top 0.152: J1.28 72.7,8.66 71.89,9.47 70.28,9.47 68.68,11.08 RN17.8
N$144
  Top 0.152: RN18.5 67.27,10.77 68.87,9.17 71.5,9.17 71.7,8.97 J1.30
N$145
  Top 0.152: J1.31 71.2,8.66 71,8.86 68.07,8.86 66.47,10.47 RN18.6
N$146
  Top 0.152: J1.32 70.7,8.56 67.26,8.56 65.67,10.15 RN18.7
N$147  (via drill 0.25 pad 0.51)
  Top 0.152: v64.85,11.89 64.87,11.91 RN18.8 | v70.21,6.71 v70.2,6.71 J1.33
  Bottom 0.152: v70.21,6.71 69.12,7.79 68.94,7.79 v64.85,11.89
N$148
  Top 0.152: J3.3 41.72,19.1 41.89,19.27 R51.2
N$149
  Top 0.152: J3.4 40.72,14.55 40.39,14.89 R65.2
N$150  (via drill 0.25 pad 0.51)
  Top 0.152: v174.32,28.6 174.48,28.44 U1.6
  Bottom 0.152: v174.32,28.6 174.32,23.34 171.15,20.17 167.51,20.17 164.34,23.34 164.34,29.9 162.74,31.5 156.03,31.5 155.63,31.09 155.63,12.27 149.28,5.92 139.24,5.92 JP4.2
N$151
  Top 0.152: JP4.3 110.69,4.32 BT1.1
N$152  (via drill 0.25 pad 0.51)
  Top 0.152: v22.38,22.3 R75.1 24.25,20.26 T2.E
  Bottom 0.152: C64.1 21.84,29.08 U2.3 21.84,25.4 22.38,24.87 v22.38,22.3
N$153
  Top 0.152: C24.2 164.01,19.07 Q1.2 165.43,18.73 165.95,19.25 R13.2
N$154
  Top 0.152: C25.2 164.01,16.56 Q1.1 166.57,16.83 166.76,16.64 R74.2
N$155
  Top 0.152: T2.B R79.1
N$156
  Top 0.152: JP6.2 7.77,5.26 18.97,5.26 20.57,6.86 24.18,6.86 28.45,2.59 R76.1
N$157  (via drill 0.25 pad 0.51)
  Top 0.152: v35.81,6.07 33.2,6.07 33.2,2.59 R76.2
  Bottom 0.152: v35.81,6.07 U2.25
N$158  (via drill 0.25 pad 0.51)
  Top 0.152: v34.67,13.16 R77.2
  Bottom 0.152: U2.24 34.67,12.6 v34.67,13.16
N$159  (via drill 0.25 pad 0.51)
  Top 0.152: v31.75,6.66 31.75,4.92 R78.2
  Bottom 0.152: U2.27 33.27,8.18 v31.75,6.66
N$160  (via drill 0.25 pad 0.51)
  Top 0.152: v30.51,7.06 arc1 R80.2
  Bottom 0.152: U2.28 32,8.1 30.96,7.06 v30.51,7.06
NRST  (via drill 0.25 pad 0.51)
  Top 0.152: 160.74,8.97 S1.2 160.74,3.38 158.96,1.6 41.91,1.6 38.73,4.78 38.73,6.52 J3.6 | v156.39,31.01 156.09,31.31 R9.1 | 160.74,8.97 160.43,9.27 159.02,9.27 C5.1 | 160.74,8.97 161.04,9.27 v163.73,9.27 | v186.82,28.6 186.98,28.44 U1.31
  Bottom 0.152: 165.28,19.18 164.85,19.18 164.03,19.99 164.03,29.41 162.43,31.01 v156.39,31.01 | 165.28,19.18 163.73,17.63 v163.73,9.27 | v186.82,28.6 185.24,30.17 177.98,30.17 174.8,27 174.8,22.35 171.63,19.18 165.28,19.18
PA0
  Top 0.152: U1.40 191.48,25.98 191.46,25.96 TP29.TP
PA1
  Top 0.152: TP30.TP 191.98,25.43 U1.41
PA7
  Top 0.152: TP19.TP U1.53
PA9
  Top 0.152: TP21.TP 177.98,54.15 | 177.98,54.15 | 177.98,54.15 U1.120
PB2
  Top 0.152: TP22.TP 196.67,35.76 196.66,35.78 U1.58
PB5
  Top 0.152: TP23.TP 167.78,35.78 U1.163
PC0
  Top 0.152: TP1.TP U1.32
PC1  (via drill 0.25 pad 0.51)
  Top 0.152: v187.48,28.6 187.72,28.6 187.98,28.35 U1.33 | v187.48,23.72 187.73,23.72 187.99,23.98 TP2.TP
  Bottom 0.152: v187.48,23.72 v187.48,28.6
PC2
  Top 0.152: TP5.TP 188.48,25.43 U1.34
PC4  (via drill 0.25 pad 0.51)
  Top 0.152: v198.93,34.49 TP3.TP | v197.23,33.78 U1.54
  Bottom 0.152: v197.23,33.78 198.22,33.78 v198.93,34.49
PC5
  Top 0.152: TP10.TP 196.67,34.29 196.66,34.28 U1.55
PC7
  Top 0.152: TP17.TP 179.98,55.21 U1.116
PC8
  Top 0.152: TP16.TP 179.5,55.42 179.48,55.4 U1.117
PD2
  Top 0.152: TP24.TP 167.83,45.28 U1.144
PD3  (via drill 0.25 pad 0.51)
  Top 0.152: v165.84,44.76 166.52,44.76 TP25.TP | v171.3,44.78 | v171.3,44.78 U1.145
  Bottom 0.152: v171.3,44.78 171.27,44.76 v165.84,44.76
PD4
  Top 0.152: TP31.TP 167.78,44.28 U1.146
PD5
  Top 0.152: TP32.TP 166.59,43.77 168.28,43.77 168.29,43.78 U1.147
PD6
  Top 0.152: TP11.TP 167.78,42.28 U1.150
PD7  (1 unrouted)
  Top 0.152: TP12.TP 166.59,41.74 168.28,41.74 168.32,41.78 U1.151
PDR_ON
  Top 0.152: R10.2 164.95,30.23 164.95,30.96 165.77,31.78 U1.171
PE4
  Top 0.152: U1.3 172.98,25.5 TP13.TP
PF8
  Top 0.152: U1.26 184.48,25.96 183.87,25.35 183.87,25.02 TP33.TP
PF9
  Top 0.152: U1.27 184.96,27.3 TP34.TP
PG10
  Top 0.152: TP35.TP 167.78,40.78 U1.153
PH1
  Top 0.152: TP47.TP 186.61,25.96 186.48,26.09 U1.30
PH4
  Top 0.152: TP36.TP U1.45
PI3
  Top 0.152: TP40.TP 167.83,50.28 U1.134
PI8
  Top 0.152: TP41.TP U1.7
PI11
  Top 0.152: TP45.TP U1.13
POWER_LED  (via drill 0.25 pad 0.51)
  Top 0.152: v189.99,25.96 189.18,25.96 188.98,26.16 U1.35 | v196.14,13.84 R28.2
  Bottom 0.152: v196.14,13.84 194.69,13.84 193.88,14.66 193.88,24.36 192.28,25.96 v189.99,25.96
PWM_CPUFAN
  Top 0.152: U1.24 183.48,23.47 185.08,21.87 229.39,21.87 240.56,10.69 R52.1
PWM_HEATER  (via drill 0.25 pad 0.51)
  Top 0.152: v183.46,28.6 183.72,28.6 183.98,28.35 U1.25 | v194.36,26.44 195.53,25.27 221.64,25.27 223.24,26.87 223.24,28.32 224.05,29.13 228.42,29.13 230.03,30.74 230.03,32.11 230.43,32.51 230.78,32.51 232.38,34.11 232.38,34.72 232.6,34.94 R54.1
  Bottom 0.152: v194.36,26.44 189.56,26.44 187.96,24.84 187.96,23.44 187.76,23.24 186.64,23.24 183.46,26.42 v183.46,28.6
SCK  (via drill 0.25 pad 0.51)
  Top 0.152: v162.48,47.78 v162.49,47.78 U1.139 | v162.48,67.39 R49.1
  Bottom 0.152: v162.48,67.39 v162.48,47.78
SDCKE1
  Top 0.152: U1.84 196.57,48.78 196.57,49.71 198.17,51.31 206.1,51.31 207.24,52.45 216.97,52.45 217.78,51.64 R15.1
SDCLK  (via drill 0.25 pad 0.51)
  Top 0.152: v181.13,56.92 R16.1 | v181.97,54.05 181.98,54.04 U1.112
  Bottom 0.152: v181.97,54.05 181.97,56.08 v181.13,56.92
SDI  (via drill 0.25 pad 0.51)
  Top 0.152: v164.64,67.39 R48.1 | v168.71,47.27 168.72,47.28 U1.140
  Bottom 0.152: v168.71,47.27 164.64,51.33 v164.64,67.39
SDNCAS
  Top 0.152: R68.1 167.07,37.28 U1.160
SDNE1  (via drill 0.25 pad 0.51)
  Top 0.152: v216.31,51 198.48,51 196.88,49.4 196.88,48.49 196.67,48.28 U1.83 | v217.22,28.55 221.23,28.55 R42.1
  Bottom 0.152: v217.22,28.55 217.22,50.09 v216.31,51
SDNRAS  (via drill 0.25 pad 0.51)
  Top 0.152: v196.75,36.27 196.74,36.28 U1.59 | v203.73,36.27 203.73,26.75 204.55,25.93 218.26,25.93 219.08,26.75 R67.1
  Bottom 0.152: v203.73,36.27 v196.75,36.27
SDNWE
  Top 0.152: R69.1 196.36,27.38 195.95,27.79 195.15,27.79 194.34,28.6 194.34,29.78 U1.46
SDO  (via drill 0.25 pad 0.51)
  Top 0.152: v160.76,46.96 160.94,46.78 U1.141 | v160.27,67.39 R50.1
  Bottom 0.152: v160.27,67.39 160.76,66.9 v160.76,46.96
TCK
  Top 0.152: R7.1 155.07,42.95 154.91,43.1 154.91,48.36 155.33,48.78 U1.137
TDI
  Top 0.152: R3.1 155.87,48.28 U1.138
TDO  (via drill 0.25 pad 0.51)
  Top 0.152: v168.07,36.78 U1.161 | v167.06,39.24 156.46,39.24 156.04,38.82 R8.1
  Bottom 0.152: v167.06,39.24 168.07,38.23 v168.07,36.78
TMS  (via drill 0.25 pad 0.51)
  Top 0.152: v156.79,45.41 R4.1 | v156.79,54.48 156.85,54.53 175.77,54.53 175.98,54.32 U1.124
  Bottom 0.152: v156.79,54.48 v156.79,45.41
TP_SCL
  Top 0.152: R51.1 R36.1 41.61,22.82 41.2,22.42 41.2,20.22 41,20.02 39.83,20.02 39.01,20.83 39.01,26.09 40.01,27.08 157.91,27.08 159.51,28.68 159.51,34.04 161.11,35.64 166.19,35.64 166.57,35.26 170,35.26 U1.164
TP_SDA  (via drill 0.25 pad 0.51)
  Top 0.152: R65.1 40.41,20.97 R41.1 39.62,22.82 39.62,25.4 40.21,25.98 121.41,25.98 121.59,26.16 165.48,26.16 v165.53,26.11 | v167.79,34.77 v167.8,34.78 U1.165
  Bottom 0.152: v167.79,34.77 165.53,32.51 v165.53,26.11
TRST  (via drill 0.25 pad 0.51)
  Top 0.152: v158.55,50.57 R1.1 | v168.71,36.27 169.33,36.27 169.34,36.28 U1.162
  Bottom 0.152: v168.71,36.27 164.9,36.27 158.55,42.62 v158.55,50.57
TS_ADDR0  (via drill 0.25 pad 0.51)
  Top 0.152: v205.41,54.66 208.99,54.66 209.79,55.46 IC2.1 | v194.16,46.28 U1.79
  Bottom 0.152: v194.16,46.28 203.81,46.28 205.41,47.88 v205.41,54.66
TS_ADDR1  (via drill 0.25 pad 0.51)
  Top 0.152: v196.75,45.8 196.75,46.61 196.58,46.78 U1.80 | v209.27,55.63 209.27,57.17 209.47,57.38 210.44,57.38 IC2.2
  Bottom 0.152: v209.27,55.63 209.27,48.97 206.1,45.8 v196.75,45.8
TS_ADDR2  (via drill 0.25 pad 0.51)
  Top 0.152: v196.77,54.18 210.29,54.18 211.09,54.98 IC2.3 | v194.95,55.14 192.79,55.14 191.98,54.34 U1.92
  Bottom 0.152: v194.95,55.14 196.37,55.14 196.77,54.74 v196.77,54.18
TS_EN  (via drill 0.25 pad 0.51)
  Top 0.152: v176.45,35.1 174.63,33.28 U1.168 | v186.97,57.71 187.66,57.02 193.83,57.02 195.43,55.42 195.43,54.1 195.83,53.7 211.43,53.7 213.04,55.31 IC2.6
  Bottom 0.152: v186.97,57.71 180.9,57.71 179.3,56.11 179.3,37.95 v176.45,35.1
TS_SCK  (via drill 0.25 pad 0.51)
  Top 0.152: U$3.5 192.86,68.12 197.87,68.12 200.08,65.91 v200.89,65.91 201.93,65.91 U$4.5 | U$5.5 214.2,66.98 214.2,68.02 214.4,68.22 v218.26,68.22 218.64,68.22 219.89,66.98 U$6.5 | v202.9,60.35 182.63,60.35 182.22,59.94 182.22,56.97 183.03,56.16 191.26,56.16 191.48,55.94 U1.93
  Bottom 0.152: v218.26,68.22 202.23,68.22 201.63,67.62 | 201.63,67.62 200.89,66.88 v200.89,65.91 | 201.63,67.62 201.93,67.31 201.93,65.58 202.9,64.62 v202.9,60.35
TS_SDI  (via drill 0.25 pad 0.51)
  Top 0.152: R19.1 227.24,63.7 218.1,63.7 217.89,63.91 R18.1 217.82,64.72 217.82,63.88 v210.13,63.88 | R27.1 200.66,64.67 201.42,63.91 206.18,63.91 R17.1 v207.11,64.8 | v189.66,55.68 189.79,55.8 190.88,55.8 191.08,55.6 191.08,53.98 190.98,53.87 U1.94 | v203.38,57.51 v189.66,57.51
  Bottom 0.152: v189.66,57.51 v189.66,55.68 | v203.38,57.51 203.38,63.2 204.98,64.8 v207.11,64.8 209.22,64.8 v210.13,63.88
TS_SDO
  Top 0.152: TP46.TP 190.48,55.2 U1.95
U0RX  (via drill 0.25 pad 0.51)
  Top 0.152: v22.53,13.23 11.58,24.18 4.42,24.18 4.45,24.21 SV2.2
  Bottom 0.152: U2.34 24.38,11.38 v22.53,13.23
U0TX  (via drill 0.25 pad 0.51)
  Top 0.152: v21.72,12.52 11.13,23.11 1.96,23.11 1.91,23.16 SV2.1
  Bottom 0.152: U2.35 23.11,11.13 v21.72,12.52
USART2_RX  (via drill 0.25 pad 0.51)
  Top 0.152: SV5.2 R24.2 | v197.38,28.09 198.32,29.03 198.32,29.87 197.91,30.28 U1.47 | v23.11,6.37 28.19,1.29 181.58,1.29 184.76,4.47 v184.76,7.49 | R80.1 25.07,7.04 v25.07,7.87
  Bottom 0.152: SV5.2 181.05,7.49 | 181.05,7.49 181.05,9.02 182.65,10.62 196.57,10.62 197.38,11.43 v197.38,28.09 | 181.05,7.49 v184.76,7.49 | v23.11,6.38 v23.11,6.37 23.14,6.37 23.14,7.87 v25.07,7.87
USART2_TX  (via drill 0.25 pad 0.51)  (1 unrouted)
  Top 0.152: v192.53,24.92 192.53,25.93 192.48,25.99 U1.42 | v178.51,7.87 R23.2 | v178.05,15.95 v177.04,15.95 | 30,4.94 R78.1 v28.14,4.9
  Bottom 0.152: 178.51,8.61 v178.51,7.87 SV5.1 | 178.51,8.61 184.87,14.97 190.4,14.97 193.57,18.15 193.57,23.88 v192.53,24.92 | v177.04,15.95 177.04,4.42 173.86,1.25 50.32,1.25 45.54,6.02 42.88,6.02 42.39,5.54 28.14,5.54 v28.14,4.9 | 178.51,8.61 178.05,9.07 v178.05,15.95
USB_DM  (via drill 0.25 pad 0.51)
  Top 0.152: v176.99,71.88 160.02,71.88 159.82,72.09 159.82,72.16 153.45,78.52 X5.2 | v176.99,54.05 v176.98,54.04 U1.122
  Bottom 0.152: v176.99,54.05 v176.99,71.88
USB_DP  (via drill 0.25 pad 0.51)
  Top 0.152: v152.17,77.57 151.56,77.57 151.41,77.72 X5.3 | v151.16,54.97 176.07,54.97 176.48,54.56 U1.123
  Bottom 0.152: v151.16,54.97 151.16,76.56 v152.17,77.57
USB_ID  (via drill 0.25 pad 0.51)
  Top 0.152: v175.97,69.06 159.59,69.06 159.18,69.47 159.18,70.56 152.82,76.92 X5.4 | v177.44,51.46 177.48,51.49 U1.121
  Bottom 0.152: v177.44,51.46 175.97,52.93 v175.97,69.06
WIFI_EN  (via drill 0.25 pad 0.51)
  Top 0.152: U1.5 173.98,20.19 v173.99,20.19 | v173.99,7.39 173.99,6.04 v175.18,4.85 | v173.71,3.38 v175.26,1.83 | v1.35,0.86 1.35,21.44 11.46,21.44 21.44,11.45 25.27,11.45 26.75,12.93 26.75,17.31 R79.2
  Bottom 0.152: v173.99,20.19 v173.99,7.39 | v175.18,4.85 v173.71,3.38 | v175.26,1.83 175.51,1.58 175.51,0.86 v1.35,0.86

## Text on the board
tPlace: **DNP** | 4.7uf | 4.7uf | + | + | + | B550 | - | - | + | - | - | 10k | 5.6uH | 0.1uF | RT8289 | 10uF | FB / (100R / @100Mhz) | 0R | *OVEN* | *PCB* | 0.01uF | 0.01uF | 0.01uF | MBR0530 | 10-22uH | .01uf | *USB* | 0.01uF | 0.01uF | BUZZER | 0.01uF | 2.0k | FAN5333B | .01uf | 4.7uf | 4.7uf | 5.6k | 0.01uF | 0.01uF | 0.01uF | 0.01uF | 0.01uF | 0.01uF | MAX31855 | 120k | MAX31855 | MAX31855 | MAX31855 | *1A OR >* | POWER LEDS | 1.0uF | 0.1uF | 0.1uF | NPN | 100R | 10uF | 10uF | 10uF | 10uF | 4.7k | 10uF | 68R | 68R | 68R | 0.1uF | 0.1uF | 3V3 | *MICROSD* | DNP | 20R | 20R | 20R | 20R | 3V3_TP | 5V0 | 390R | 5V0_TP | 240R | 10k | 2.2uf | 33R | 33R | 33R | 74HC138 | CS6 | 4.7uf | 4.7uf | 10k | 4.7uf | CS5 | 1.0uH | 0.1uF | B550 | 0.1uF | CS4 | 5.6uH | PC8 | CS7 | 4.7uf | FB / (100R / @100Mhz) | PD12 | .01uF | 10uF | RT8289 | PA9 | PC7 | PG3 | TS_SDO | PD13 | PD11 | 2.2uf | .1uF | LEDS | 0R | 4.7uf | 4.7uf | * | .01uf | 3.16k | .01uf | STLINK/JTAG | PI3 | 0R | 33R | 33R | 20R | 33R | 33R | 33R | 330R | 120VAC IN | 20R | 20R | PD2 | PD3 | 330R | 10k | 20R | PD5 | PD4 | PD6 | STM32H7 | 0.1uF | 10uF | 10k | PD7 | NPN | 1.5A - 5x20mm | PG10 | 64MB SDRAM | PG13 | N-FET | 20R | 0.1uF | HEATER | 33R | *1M - 400V* | PB5 | PB2 | 1k | 10k | 1k | 20R | PC5 | 33R | PC4 | 100R | PA7 | DAC1_OUT2 | 33R | * | 100R | * | 10k | FL5160 | * | PH4 | 2.0k | VOM1271 | 33R | 33R | 33R | 10k | NPN | PROG | 80k | 33R | 33R | FAN5333B | NPN | TX | Rx | GND | 3V3 | 4.7k | 4.7k | * | 33R | 12V REG | PI8 | PC2 | PA1 | 10uF | N-FET | COOL FAN | PE2 | PE3 | PE4 | PI11 | PF9 | PH1 | PC0 | 1.0uF | 1k | 22nF | 10uF | PF8 | PC1 | PA0 | LOPWR | 470uF | 10k | NPN | 1k | ** ML2032 ONLY ** | RTC CLOCK | 0.1uF | 10-22uH | MBR0530 | 0.1uF | *1A OR >* | 33R | 1.5pF | 0R | 4k7 | 1k | 1k | 33R | 4.7k | 0R | 68R | 32.768Khz | 0R | *DNP* | 4.7uF | 10uF | 68R | 68R | 68R | 68R | 68R | 1.5pF | POWER LED | .01uF | 470uF | 470uF | .01uF | 4.7k | 68R | 2k | 24MHZ CLOCK | 10k | 1.0uH | 24Mhz | RESET | BOOT | RS232 | 10k | 1k | CPU FAN | 4.7k | 50R | 9VAC IN | 0.1uF | 10k | 4.7k | NPN | *1 | 240R | .01uF | 0.1uF | *1 | 50R | *1 | 10uF | BATTERY | WIFI BOOT | .01uF | 10k | NPN | 50R | FLASH | ROM | TX | RX | GND | 3V3 | T962A CONTROLLER V3.5 | 10k | ON | OFF | NRM | PROG
bPlace: 0.1uF