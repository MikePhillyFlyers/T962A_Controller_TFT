# EAGLE board T962A_Controller_V3.0B (EAGLE 7.7.0), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
GND  (via drill 0.25 pad 0.51, 4.06 pad 6.6)  (2 unrouted) (continued)
  other vias: 261.47,9.27 252.5,23.04 255.42,52.45 225.5,17.42 210.52,16.66 220.27,16.59 228.19,13.28 222.63,12.45 204.34,6.22 211.71,6.53 226.14,8.51 229.87,2.97 189.2,1.55 204.67,1.55 218.03,1.3 190.4,5.11 162.94,7.67 163.88,5.74 117.55,8 125.17,10.49 153.42,7.72 152.35,10.64 137.92,10.72 131.7,7.47 141.5,7.21 105.36,9.83 108.05,12.78 101.3,11.61 89.31,12.95 43.94,4.11 36.37,15.01 42.75,14.96 44.22,10.59 40.03,12.34 36.5,10.19 40.21,5.84 25.5,27.1 4.14,26.64 4.72,17.91 25.65,17.65 26.06,8.79 3.78,2.95 20.55,2.74 17.17,12.24 16.36,23.37 228.75,62.74 222.73,61.67 218.67,61.67 220.47,72.49 211.45,70.66 218.92,76.78 218.87,80.98 209.12,81.76 209.91,73.94 209.25,77.65 199.09,75.44 199.31,79.96 177.7,78.87 167.46,82.83 176.3,83.59 186.11,83.41 186.54,79.07 179.6,62.56 189.26,66.04 188.11,74.12 180.19,73.48 185.39,69.77 181.84,81.1 168.2,70.18 173.35,68.3 174.55,66.98 168.2,65.96 172.87,62.46 167.59,57.25 172.44,56.82 170.13,60.5 154.81,83.69 157.84,79.48 155.93,75.34 153.54,72.85 152.68,70.56 155.91,70.36 146.96,84.23 143.18,69.82 143.69,58.01 157.58,57.2 157.66,65.23 152.53,65.38 151.26,57.48 154.86,61.34 180.16,38.58 180.09,32.03 231.55,43.41 233.22,36.8 235.99,40.59 236.02,44.7 207.98,36.2 211.15,37.57 227.81,39.37 227.76,36.75 249.66,75.31 252.32,77.32 76.48,4.98 84.38,5.18 79.27,4.98 195.48,70.36 204.11,70.64 151.76,50.32 149.53,47.93 149.12,44.04 152.25,44.04 150.72,37.44 151.16,30.23 152.88,32 152.35,34.44 215.82,70.33 225.3,70.21 233.65,79.32 199.29,83.85 218.9,84.05 235,55.91 201.83,15.95
  pour Bottom (isolate 0.508): 0,0 0,30.1 141,30.1 141,85.85 263.93,85.85 263.93,0
  pour Top (isolate 0.508): 0,0 0,30.1 141,30.1 141,85.85 263.93,85.85 263.93,0
LCD_ADJ  (via drill 0.25 pad 0.51)
  Top 0.152: U$1.4 256.86,67.97 R37.2 256.55,65.42 250.19,59.06 v236.91,59.06 | v196.75,32.84 196.75,32.78 196.49,32.53 U1.52
  Bottom 0.152: v236.91,59.06 232.92,59.06 232.92,49.61 226.5,43.19 226.5,34.27 224.21,31.97 224.21,24.79 217.86,18.44 212.39,18.44 210.79,20.04 210.79,28.93 207.62,32.11 197.49,32.11 v196.75,32.84
LCD_B0  (via drill 0.25 pad 0.51)
  Top 0.152: v143.74,28.32 151.97,28.32 155.14,31.5 155.14,38.2 155.35,38.41 168.22,38.41 168.35,38.53 U1.157 | v55.12,20.07 57.79,20.07 59.39,18.47 RN16.4
  Bottom 0.152: v55.12,20.07 55.14,20.09 55.14,25.15 58.32,28.32 v143.74,28.32
LCD_B1  (via drill 0.25 pad 0.51)
  Top 0.152: v55.6,18.77 56.99,18.77 58.59,17.17 RN16.3 | v145.9,39.17 160.99,39.17 161.39,39.57 168.84,39.57 168.88,39.53 U1.155
  Bottom 0.152: v145.9,39.17 145.9,29.19 144.3,27.58 58.78,27.58 55.6,24.41 v55.6,18.77
LCD_B2  (via drill 0.25 pad 0.51)
  Top 0.152: v57.81,15.24 57.81,14.5 57.79,14.48 RN16.2 | v178.03,51.11 178.77,51.11 178.98,51.31 U1.118
  Bottom 0.152: v178.03,51.11 178.03,20.28 177.22,19.47 177.16,19.47 173.97,16.28 173.97,5.49 172.36,3.89 88.29,3.89 86.69,5.49 86.69,20.91 80.31,27.28 59.39,27.28 56.21,24.11 56.21,16.84 v57.81,15.24
LCD_B3  (via drill 0.25 pad 0.51)
  Top 0.152: v148.79,39.88 168.22,39.88 168.37,40.03 U1.154 | v148.79,16.94 71.98,16.94 71.17,16.13 71.17,13.82 71.02,13.67 56.99,13.67 RN16.1
  Bottom 0.152: v148.79,16.94 v148.8,16.95 v148.8,39.87 v148.79,39.88
LCD_B4  (via drill 0.25 pad 0.51)
  Top 0.152: v58.09,16.49 56.42,16.49 55.61,15.67 RN17.4 | v62.84,24.64 162.97,24.64 166.14,27.81 166.14,30.12 166.55,30.53 U1.173
  Bottom 0.152: v62.84,24.64 61.26,24.64 58.09,21.46 v58.09,16.49
LCD_B5  (via drill 0.25 pad 0.51)
  Top 0.152: v63.63,24.16 163.6,24.16 166.77,27.33 166.77,29.82 166.98,30.03 U1.174 | v54.97,15.55 54.81,15.39 RN17.3
  Bottom 0.152: v54.97,15.55 55.75,14.76 62.81,14.76 63.63,15.57 v63.63,24.16
LCD_B6  (via drill 0.25 pad 0.51)
  Top 0.152: v167.31,22.15 167.13,21.97 54.82,21.97 54.01,21.16 RN17.2 | v167.31,29.52 v167.32,29.53 U1.175
  Bottom 0.152: v167.31,29.52 v167.31,22.15
LCD_B7  (via drill 0.25 pad 0.51)
  Top 0.152: v53.21,23.52 165.25,23.52 168.43,26.7 168.43,28.62 168.83,29.03 U1.176 | v53.21,15.24 v53.21,15.23 RN17.1
  Bottom 0.152: v53.21,15.24 v53.21,23.52
LCD_CLK  (via drill 0.25 pad 0.51)
  Top 0.152: RN6.8 51.8,16.59 51.89,16.59 52.3,16.99 52.3,18.39 | v53.87,13.49 51.95,13.49 51.8,13.64 RN18.4 | 52.3,18.39 52.3,20.88 v53.87,22.45 | v182.47,51.21 v182.48,51.21 U1.111 | 52.3,18.39 | 52.3,18.39 47.7,18.39 v47.04,17.73
  Bottom 0.152: v53.87,22.45 v53.87,13.49 | v47.04,17.73 47.04,3.3 48.64,1.7 173.92,1.7 175.52,3.3 175.52,11.64 178.71,14.83 180.87,14.83 182.47,16.43 v182.47,51.21
LCD_DE  (via drill 0.25 pad 0.51)
  Top 0.152: v47.65,14.55 46.56,14.55 R38.1 | v185.5,23.8 185.5,25.68 185.48,25.7 U1.28 | v54.23,8.53 v54.24,8.53 J1.34
  Bottom 0.152: 47.65,18.87 v47.65,14.55 | v185.5,23.8 185.5,14.96 180.06,9.53 180.06,3.83 176.89,0.66 47.98,0.66 46.38,2.26 46.38,18.77 46.79,19.18 47.35,19.18 47.65,18.87 | 47.65,18.87 47.96,19.18 48.51,19.18 48.92,18.77 48.92,13.97 49.48,13.97 49.89,13.56 49.89,12.98 50.29,12.57 52.76,12.57 52.96,12.37 52.96,9.8 v54.23,8.53
LCD_G0  (via drill 0.25 pad 0.51)
  Top 0.152: v171.91,22.86 169.98,20.93 68.51,20.93 66.91,19.33 RN14.4 | v173.66,35.03 U1.57
  Bottom 0.152: v173.66,35.03 173.66,24.61 v171.91,22.86
LCD_G1  (via drill 0.25 pad 0.51)
  Top 0.152: v66.12,22.45 66.29,22.63 169.52,22.63 171.12,24.23 171.12,28.32 172.72,29.92 176.05,29.92 180.65,34.53 U1.56 | v66.12,15.24 v66.11,15.23 RN14.3
  Bottom 0.152: v66.12,15.24 v66.12,22.45
LCD_G2  (via drill 0.25 pad 0.51)
  Top 0.152: v60.93,26.8 60.93,27.66 61.75,28.47 141.15,28.47 141.96,29.29 141.96,52.63 143.56,54.23 173.57,54.23 173.98,53.82 U1.128 | v65.33,15.9 65.33,14.5 65.31,14.48 RN14.2
  Bottom 0.152: v65.33,15.9 65.33,25.2 63.73,26.8 v60.93,26.8
LCD_G3  (via drill 0.25 pad 0.51)
  Top 0.152: v173.63,51.21 173.48,51.36 U1.129 | v64.11,25.68 152.88,25.68 156.06,28.85 v156.06,33.91 | v64.11,15.9 64.51,15.5 RN14.1
  Bottom 0.152: v156.06,33.91 171.25,33.91 172.85,35.51 172.85,49.43 172.01,50.27 172.01,51 172.21,51.21 v173.63,51.21 | v64.11,15.9 v64.11,25.68
LCD_G4  (via drill 0.25 pad 0.51)
  Top 0.152: v172.49,50.62 172.98,51.11 U1.130 | v170,21.97 169.27,21.23 66.33,21.23 63.15,18.06 RN15.4
  Bottom 0.152: v170,21.97 170,29.79 173.18,32.97 173.18,50.42 172.97,50.62 v172.49,50.62
LCD_G5  (via drill 0.25 pad 0.51)
  Top 0.152: v62.36,24.16 62.36,25.22 63.96,26.82 141.76,26.82 142.57,27.63 142.57,50.09 144.17,51.69 171.3,51.69 171.88,51.11 172.27,51.11 172.48,51.31 U1.131 | v62.36,15.24 v62.35,15.23 RN15.3
  Bottom 0.152: v62.36,15.24 v62.36,24.16
LCD_G6  (via drill 0.25 pad 0.51)
  Top 0.152: v61.57,24.16 61.57,25.53 63.17,27.13 141.45,27.13 142.27,27.94 142.27,52.32 143.87,53.92 171.77,53.92 171.98,53.72 U1.132 | v61.57,15.24 61.55,15.22 RN15.2
  Bottom 0.152: v61.57,15.24 v61.57,24.16
LCD_G7  (via drill 0.25 pad 0.51)
  Top 0.152: v74.27,26.34 142.44,26.34 143.26,27.15 143.26,48.34 144.07,49.15 157.07,49.15 158.5,50.57 168.63,50.57 168.68,50.53 U1.133 | v54.66,21.03 59.15,21.03 60.75,19.43 RN15.1
  Bottom 0.152: v54.66,21.03 54.48,20.85 54.48,14.78 55.3,13.97 67.92,13.97 74.27,20.32 v74.27,26.34
LCD_HSYNC  (via drill 0.25 pad 0.51)
  Top 0.152: 50.19,15.19 50.19,15.77 50.2,15.77 RN6.6 | 50.19,15.19 50.19,14.48 50.2,14.48 RN18.2 | 50.19,15.19 v48.29,15.19 | v180.98,24.71 180.8,24.54 177.86,24.54 177.45,24.94 177.45,27.05 U1.12
  Bottom 0.152: v180.98,24.71 181.2,24.71 181.46,24.46 181.46,22.43 181.28,22.25 181.28,16.74 179.68,15.14 177.77,15.14 174.6,11.96 174.6,4.22 173,2.62 49.1,2.62 48.29,3.43 v48.29,15.19
LCD_LED+  (via drill 0.25 pad 0.51)
  Top 0.152: 237.95,7.39 237.95,13.23 235.1,16.1 v235.1,26.65 | 237.95,7.39 237.95,7.09 v237.13,6.27 234.16,3.3 | 237.95,7.39 227.3,7.39 223.04,3.12 107.28,3.12 103.73,6.67 C41.1 85,6.67 84.51,7.16 C40.+ 74.17,7.16 73.69,6.68 70.24,6.68 J1.2
  Top 0.203: D1.C 251.32,74.68 R45.2 251.32,72.19 v249.76,72.19 | v249.76,69.77 C15.1
  Top 0.254: D1.C v246.51,81.15
  Bottom 0.152: v246.51,81.15 242.93,77.57 242.93,29.16 239.93,26.65 v235.1,26.65 | v237.13,6.27 231.9,1.04
  Bottom 0.203: v249.76,72.19 v249.76,69.77
LCD_LED_FB
  Top 0.152: 255.04,71.62 R61.1
  Top 0.203: R45.1 254.75,72.21 R61.1 255.04,72.8 256.86,72.8 U$1.3
LCD_R0  (via drill 0.25 pad 0.51)
  Top 0.152: v190.47,13.95 190.3,13.77 113.36,13.77 107.36,7.77 90.65,7.77 84.06,14.36 RN12.4 | v190.47,28.83 192.77,28.83 192.98,28.63 U1.43
  Bottom 0.152: v190.47,28.83 v190.47,13.95
LCD_R1  (via drill 0.25 pad 0.51)
  Top 0.152: v193.32,25.71 193.48,25.86 U1.44 | v193.32,13.28 117.73,13.28 111.91,7.47 90.35,7.47 84.25,13.56 73.6,13.56 RN12.3
  Bottom 0.152: v193.32,13.28 v193.32,25.71
LCD_R2  (via drill 0.25 pad 0.51)
  Top 0.152: v178.51,17.48 158.75,17.48 157.43,16.15 72.29,16.15 71.48,15.34 71.48,13.79 71.88,13.39 72.6,13.39 72.8,13.59 RN12.2 | v180.04,44.53 190.3,44.53 193.47,47.7 193.47,48.21 194.28,49.03 U1.85
  Bottom 0.152: v180.04,44.53 178.51,43 v178.51,17.48
LCD_R3  (via drill 0.25 pad 0.51)
  Top 0.152: v184.79,19.53 184.05,19.53 179.58,15.06 72,15.06 RN12.1 | v195.3,51.56 196.16,51.56 196.57,51.16 196.57,49.53 U1.86
  Bottom 0.152: v195.3,51.56 195.3,49.84 194.49,49.02 185.55,49.02 183.95,47.42 183.95,25.35 183.77,25.17 183.77,19.74 183.97,19.53 v184.79,19.53
LCD_R4  (via drill 0.25 pad 0.51)
  Top 0.152: v157.45,18.49 72.27,18.49 70.67,16.89 RN13.4 | v193.47,50.04 193.48,50.03 U1.87
  Bottom 0.152: v193.47,50.04 186.16,50.04 183.9,52.3 178.36,52.3 177.55,51.49 177.55,22.18 175.95,20.58 168.83,20.58 166.75,18.49 v157.45,18.49
LCD_R5  (via drill 0.25 pad 0.51)
  Top 0.152: v195.91,51.08 195.71,51.08 195.45,50.83 U1.88 | v184.3,20.02 71.47,20.02 69.87,18.42 RN13.3
  Bottom 0.152: v184.3,20.02 184.3,47.12 185.9,48.72 195.1,48.72 195.91,49.53 v195.91,51.08
LCD_R6  (via drill 0.25 pad 0.51)
  Top 0.152: v174.78,24 174.78,21.92 173.18,20.32 70.67,20.32 69.07,18.72 RN13.2 | v194.03,53.42 193.98,53.42 193.78,53.62 193.48,53.62 U1.89
  Bottom 0.152: v194.03,53.42 193.93,53.31 190.04,53.31 188.44,54.91 188.44,57.02 188.24,57.23 180.42,57.23 177.24,54.05 177.24,24 v174.78,24
LCD_R7  (via drill 0.25 pad 0.51)
  Top 0.152: v173.66,22.38 171.91,20.62 69.87,20.62 68.27,19.03 RN13.1 | v174.29,48.74 181.38,48.74 182.98,50.34 U1.110
  Bottom 0.152: v174.29,48.74 174.29,23.01 v173.66,22.38
LCD_STBY  (via drill 0.25 pad 0.51)
  Top 0.152: v51,13.49 51,14.24 51,14.25 RN18.3 | v146.08,41.22 150.24,41.22 150.47,41 167.03,41 167.11,41.07 168.28,41.07 168.32,41.03 U1.152 | v52.48,15.19 51,15.19 RN6.7
  Bottom 0.152: v51,13.49 51,14.38 51.82,15.19 v52.48,15.19 52.48,25.76 55.65,28.93 141.07,28.93 142.67,30.53 142.67,40.41 143.48,41.22 v146.08,41.22
LCD_VSYNC  (via drill 0.25 pad 0.51)
  Top 0.152: RN6.5 46.28,15.89 45.47,15.08 45.47,14.15 45.87,13.74 47.85,13.74 48.16,13.44 v49.23,13.44 49.3,13.51 49.3,14.36 RN18.1 | v180.98,24.05 177.38,24.05 176.98,24.46 U1.11
  Bottom 0.152: v49.23,13.44 49.23,4.04 50.04,3.23 172.69,3.23 174.29,4.83 174.29,12.27 177.47,15.44 179.37,15.44 180.98,17.04 v180.98,24.05
N$1  (via drill 0.25 pad 0.51)
  Top 0.152: v209.19,12.85 L4.2 | v207.72,23.29 191.21,23.29 190.8,23.7 190.8,25.53 190.98,25.7 U1.39 | v207.72,18.21 C2.1 | v207.8,15.72 C4.1
  Bottom 0.152: v209.19,12.85 209.19,14.33 v207.8,15.72 207.72,15.8 v207.72,18.21 v207.72,23.29
N$2
  Top 0.152: R1.2 154.14,51.18 153.94,51.38 145.42,51.38 SV1.3
N$3
  Top 0.152: R3.2 154.17,46.81 153.96,46.61 145.67,46.61 SV1.5
N$4
  Top 0.152: LED1.C R2.1
N$5
  Top 0.152: R4.2 154.17,46.1 153.96,46.3 145.42,46.3 SV1.7
N$6
  Top 0.152: LED5.C R5.2
N$7
  Top 0.152: R7.2 154.14,41.91 153.94,41.71 145.49,41.71 SV1.9
N$9
  Top 0.152: R8.2 154.34,38.48 154.14,38.68 145.42,38.68 SV1.13
N$10
  Top 0.152: R9.2 154.39,35.94 154.19,36.14 145.42,36.14 SV1.15
N$12  (via drill 0.25 pad 0.51)
  Top 0.152: v169.09,7.26 R11.1
  Bottom 0.152: v169.09,7.26 169.04,7.21 JP1.2
N$13  (via drill 0.25 pad 0.51)
  Top 0.152: R59.1 R60.2 197.78,18.57 v188.7,18.57 | v188.7,23.29 190.48,25.07 U1.38
  Bottom 0.152: v188.7,23.29 v188.7,18.57
N$14  (via drill 0.25 pad 0.51)
  Top 0.152: v196.75,46.99 196.71,47.03 U1.81 | v199.95,53.26 199.05,53.26 198.24,54.08 C10.1
  Bottom 0.152: v199.95,53.26 199.95,47.4 199.54,46.99 v196.75,46.99
N$15  (via drill 0.25 pad 0.51)
  Top 0.152: v175.01,57.4 C9.1 | v175.49,53.8 175.48,53.79 U1.125
  Bottom 0.152: v175.49,53.8 175.49,56.92 v175.01,57.4
N$16
  Top 0.152: RN5.8 U$15.23
N$17
  Top 0.152: RN5.5 U$15.26
N$18
  Top 0.152: RN5.6 U$15.25
N$19
  Top 0.152: RN5.7 U$15.24
N$20
  Top 0.152: RN7.8 227.95,45.31 227.54,44.91 226.8,44.91 U$15.29
N$21  (via drill 0.25 pad 0.51)
  Top 0.152: C26.1 231.81,54.63 C29.1 231.61,57.28 231.57,57.32 231.57,59.41 231.14,59.84 L8.2 229.41,60.02 228.02,58.62 C39.+ 220.73,53.62 v201.4,53.62 | 171.48,42.52 v174.78,42.52 175.69,42.52 176.02,42.85 v180.98,42.85 v192.15,42.85 192.63,42.85 192.96,42.53 U1.72 | 171.48,42.52 171.78,42.22 171.78,37.95 171.36,37.53 U1.159 168.72,37.53 v168.71,37.52 | U1.136 171.42,49.03 172.54,50.14 v174.47,50.14 v174.48,50.15 U1.127 | v174.78,30.73 174.49,31.03 U1.172 | U1.6 174.48,28.22 174.78,28.52 v174.78,29.44 178.56,29.44 178.98,29.02 U1.15 178.98,25.6 179.38,25.2 182.58,25.2 182.98,25.6 U1.23 182.98,28.62 183.18,28.83 189.07,28.83 189.48,28.42 U1.36 | v186.49,53.8 v186.48,53.79 U1.103 | 171.48,42.52 170.67,42.52 170.66,42.53 U1.149 | v194.03,47.52 194.79,47.52 194.79,47.53 U1.82 | v181,53.8 180.98,53.77 U1.114 v180.98,51.21 | v194.11,32.56 194.11,31.23 194.31,31.03 U1.49 | v196.75,37.52 196.74,37.53 U1.62 | v192.48,51.21 U1.91
  Bottom 0.152: v174.78,29.44 v174.78,30.73 v174.78,42.52 174.78,49.07 174.47,49.38 v174.47,50.14 | 199.77,54.59 199.77,56.57 198.96,57.38 197.99,57.38 194.82,54.2 194.82,52.02 194.01,51.21 v192.48,51.21 191.8,50.52 188.09,50.52 186.49,52.12 v186.49,53.8 v181,53.8 | 199.77,54.59 200.99,54.59 201.4,54.18 v201.4,53.62 | 199.77,54.59 199.47,54.28 199.47,47.93 199.06,47.52 v194.03,47.52 | 193.68,37.21 192.15,38.73 v192.15,42.85 | v180.98,42.85 v180.98,51.21 | v168.71,37.52 163.8,42.42 C38.+ | v196.75,37.52 193.98,37.52 193.68,37.21 | v194.11,32.56 193.68,33 193.68,37.21
N$22
  Top 0.152: RN7.7 227.15,45.62 226.74,45.21 226.21,45.21 226,45 U$15.30
N$23
  Top 0.152: RN7.6 226.35,45.92 225.94,45.52 225.6,45.52 225.2,45.11 U$15.31
N$24
  Top 0.152: RN7.5 225.55,45.97 225.39,45.82 224.87,45.82 224.47,45.42 224.47,43.86 U$15.32
N$25
  Top 0.152: RN8.8 224.16,45.78 223.67,45.29 223.67,43.86 U$15.33
N$26
  Top 0.152: RN8.7 223.36,45.47 222.8,44.91 U$15.34
N$27  (via drill 0.25 pad 0.51)
  Top 0.152: v222.58,45.8 222.56,45.81 RN8.6 | v223.6,34.16 U$15.22
  Bottom 0.152: v223.6,34.16 223.6,44.78 v222.58,45.8
N$28
  Top 0.152: RN8.5 221.76,45.14 222,44.91 U$15.35
N$29
  Top 0.152: R12.2 220.78,47.18 221.2,46.76 U$15.36
N$30
  Top 0.203: U$7.1 284.1,81.69 C54.1
N$31
  Top 0.152: 288.98,76.52 U$8.C
  Top 0.508: U$7.8 281.81,74.57 284.1,74.57 C54.2 288.98,76.52 294.67,76.52 L2.1
N$32  (via drill 0.25 pad 0.51)
  Top 0.152: R32.1 v275.77,77.65 | v275.77,79.98 R31.2
  Top 0.203: U$7.4 277.28,80.96 R31.2
  Bottom 0.152: v275.77,77.65 v275.77,79.98
N$33
  Top 0.203: U$9.1 283.87,57.56 C88.1
N$34
  Top 0.152: 289.05,52.26 U$13.C | C88.2 283.87,51.41
  Top 0.508: U$9.8 282.04,50.8 283.87,50.8 C88.2 289.05,52.26 289.05,51.46 294.69,51.46 L3.1
N$35  (via drill 0.25 pad 0.51)
  Top 0.152: 275.92,53.76 R34.1
  Top 0.203: v275.89,56.34 275.89,57.29 R33.2 277.99,57.32 U$9.4 | v275.89,54.81 275.89,53.76 R34.1
  Bottom 0.203: v275.89,56.34 v275.89,54.81
N$36
  Top 0.152: R15.2 217.78,46.18 218.19,45.77 219.99,45.77 220.4,45.37 U$15.37
N$37  (via drill 0.25 pad 0.51)
  Top 0.152: v206.65,59.89 206.5,60.05 181.13,60.05 R16.2 | v220.73,51.89 220.73,48.13 220.52,47.93 217.04,47.93 216.84,47.73 216.84,46.27 217.65,45.46 219.2,45.46 219.6,45.06 U$15.38
  Bottom 0.152: v220.73,51.89 209.83,51.89 206.65,55.07 v206.65,59.89
N$38
  Top 0.152: R42.2 221.23,32.95 U$15.19
N$39
  Top 0.152: R67.2 219.99,29.22 220.4,29.63 U$15.18
N$40  (via drill 0.25 pad 0.51)
  Top 0.152: v164.44,37.08 R68.2 | v191.85,36.68 v172.36,36.68 | v200.99,31.45 200.99,27.94 202.59,26.34 214.91,26.34 218.08,29.52 218.08,29.87 218.49,30.28 218.78,30.28 219.6,31.09 U$15.17
  Bottom 0.152: v172.36,36.68 164.85,36.68 v164.44,37.08 | v200.99,31.45 193.45,31.45 191.85,33.05 v191.85,36.68
N$41  (via drill 0.25 pad 0.51)
  Top 0.152: v218.54,24.26 198.87,24.26 198.06,25.07 R69.2 | v218.54,30.76 218.8,31.01 U$15.16
  Bottom 0.152: v218.54,30.76 v218.54,24.26
N$42  (via drill 0.25 pad 0.51)
  Top 0.152: v220.57,42.65 218.95,42.65 218.8,42.8 U$15.39 | v177.06,22.86 181.03,22.86 181.2,22.68 220.4,22.68 v220.57,22.86 | v162.86,33.1 162.5,33.46 R70.2
  Bottom 0.152: v220.57,22.86 v220.57,42.65 | v162.86,33.1 162.86,24.66 166.04,21.49 175.69,21.49 v177.06,22.86
N$43  (via drill 0.25 pad 0.51)
  Top 0.152: v217.88,31.73 217.88,32.35 218,32.46 U$15.15 | v154,14.38 183.03,14.38 187.7,19.05 v212.8,19.05 | v157.38,29.11 160.4,32.13 R71.2
  Bottom 0.152: v212.8,19.05 217.88,24.13 v217.88,31.73 | v157.38,29.11 155.6,29.11 154,27.51 v154,14.38
N$44  (via drill 0.25 pad 0.51)
  Top 0.152: v222.78,34.16 222.8,34.15 U$15.21 | v207.37,58.37 183.41,58.37 183.26,58.52 R72.2
  Bottom 0.152: v207.37,58.37 207.37,56.1 210.54,52.93 223.68,52.93 224.49,52.12 224.49,33.81 224.08,33.4 223.55,33.4 v222.78,34.16
N$45
  Top 0.152: RN4.4 210.8,31.03 211.6,31.83 U$15.7
N$46
  Top 0.152: RN4.3 U$15.5
N$47
  Top 0.152: RN4.2 U$15.4
N$48
  Top 0.152: RN4.1 208.4,30.82 207.6,31.62 U$15.2
N$49
  Top 0.152: RN3.4 215.22,30.7 216.4,31.88 U$15.13
N$50
  Top 0.152: RN3.3 214.42,31.15 214.8,31.52 U$15.11
N$51
  Top 0.152: RN3.2 213.62,31.45 214,31.83 U$15.10
N$52
  Top 0.152: RN3.1 212.82,31.33 212.4,31.75 U$15.8
N$53
  Top 0.152: RN2.1 215.55,45.75 216.4,44.91 U$15.42
N$54
  Top 0.152: RN2.2 214.75,43.86 U$15.44
N$55
  Top 0.152: RN2.3 213.95,43.86 U$15.45
N$56
  Top 0.152: RN2.4 213.15,45.66 212.4,44.91 U$15.47
N$57
  Top 0.152: RN1.4 208.43,45.74 207.6,44.91 U$15.53
N$58
  Top 0.152: RN1.3 209.23,43.86 U$15.51
N$59
  Top 0.152: RN1.2 210.03,43.86 U$15.50
N$60
  Top 0.152: RN1.1 210.83,45.68 211.6,44.91 U$15.48
N$61
  Top 0.305: U$1.1 258.76,74.68 D1.A
  Top 0.406: U$1.1 258.76,73.03 U$2.2
N$62
  Top 0.152: R73.2 207.73,59.3 207.87,59.44 212.19,59.44 212.95,60.2 227.18,60.2 228.6,61.62 232.21,61.62 232.61,61.21 232.61,52.35 229.46,49.2 229.46,37.52 230.28,36.7 230.48,36.7 230.89,36.3 230.89,32.51 227.38,29.01 223.77,29.01 223.37,29.41 223.37,30.23 222,31.6 U$15.20
N$68
  Top 0.152: R27.2 195.42,66.62 U$3.7
N$69
  Top 0.152: R17.2 U$4.7
N$70
  Top 0.152: R18.2 U$5.7
N$71
  Top 0.152: R19.2 225.54,66.73 U$6.7
N$72  (via drill 0.25 pad 0.51)
  Top 0.152: C52.2 198.04,74.22 197.64,74.62 v196.85,74.62 C53.1 195.4,74.62 U$3.2
  Bottom 0.152: v196.85,74.62 v196.85,74.63 X1.1
N$73  (via drill 0.25 pad 0.51)
  Top 0.152: X1.2 193.35,74.8 193.52,74.62 C53.2 194.13,74.62 U$3.3 | v191.44,76.07 C48.2
  Bottom 0.152: X1.2 193.35,77.98 v191.44,76.07
N$74  (via drill 0.25 pad 0.51)
  Top 0.152: C21.2 207.19,74.5 206.78,74.91 v205.31,74.91 C19.1 204.47,74.91 U$4.2
  Bottom 0.152: v205.31,74.91 205.25,74.96 X2.1
N$75
  Top 0.152: 200.66,74.91 203.2,74.91 | 203.2,74.91 U$4.3 | 203.2,74.91 C19.2 | 200.66,74.91 200.66,78.69 X2.2 | 200.66,74.91 C20.2
N$76
  Top 0.152: C22.1 216.17,78.31 216.35,78.49 X3.1 | C22.1 218.44,74.8 218.85,74.4 C60.2 | C22.1 216.17,73.47 216.18,73.46 U$5.2
N$77  (via drill 0.25 pad 0.51)
  Top 0.152: C23.2 212.37,74.98 v212.88,75.49 214.87,75.49 C22.2 214.91,74.8 U$5.3
  Bottom 0.152: v212.88,75.49 212.85,75.51 X3.2
N$78
  Top 0.152: 225.53,74.73 224.84,74.73 X4.1 | 225.53,74.73 U$6.2 | 225.53,74.73 C61.1 227.84,74.73 228.24,74.32 C63.2
N$79
  Top 0.152: X4.2 221.34,78.41 221.89,77.85 C62.2 222.77,74.16 223.34,74.73 C61.2 224.26,74.73 U$6.3
N$80
  Top 0.61: J5.1 291.54,28.6 U$11.4
N$81
  Top 0.152: R53.2 242.24,8.57 T4.B R52.2
N$82
  Bottom 0.61: J4.2 295.17,41.99 295.17,32.23 J5.2
N$84
  Top 0.152: T6.B 257.92,25.52 257.52,25.12 R20.2 259.04,23.52 C27.2
N$85
  Top 0.152: R62.2 254.81,21.65 U$10.8
N$86
  Top 0.152: R63.2 256.79,21.65 256.79,24.89 256.84,24.95 U$10.10
N$87
  Top 0.61: J4.1 289.31,38.02 289.31,45.34 F1.2
N$88
  Top 0.152: R20.1 255.83,23.52 U$10.9
N$89
  Top 0.203: R40.1 257.66,34.9 256.84,34.09 U$10.1
N$90
  Top 0.152: T7.B 254.03,38.64 254.84,37.83 R64.2 R44.1
N$91
  Top 0.152: JP3.1 T4.C
N$92  (via drill 0.25 pad 0.51)
  Top 0.254: U$12.4 279.45,35.94 266.13,35.94 R40.2
  Top 0.61: v277.65,40.84 279.45,40.84 279.45,35.94
  Bottom 0.61: F1.1 265.18,45.31 265.18,41.78 277.65,41.78 v277.65,40.84
N$93  (via drill 0.25 pad 0.51)
  Top 0.508: U$12.3 v270.92,33.66 | U$11.3 v270.92,26.31 270.92,27.74 U$14.3
  Bottom 0.508: v270.92,33.66 v270.92,26.31
N$94  (via drill 0.25 pad 0.51)
  Top 0.152: U$11.1 273.05,30.88 273.46,31.29 | v272.87,37.31
  Top 0.254: 273.46,31.29 v274.37,31.29 | v272.87,37.31 U$12.1
  Top 0.508: U$11.1 269.85,30.88 269.85,30.28 U$14.4
  Bottom 0.254: v272.87,37.31 274.37,35.81 v274.37,31.29
N$95
  Top 0.152: T6.C 259.82,27.74
  Top 0.254: 259.82,27.74 U$14.2
N$96
  Top 0.152: U$14.1 262.15,30.29
  Top 0.254: 262.15,30.29 R25.1
N$97
  Top 0.203: U$10.4 253.8,34.62 254.81,34.62 U$10.3
N$98  (1 unrouted)
  Top 0.203: U$17.1 242.85,22.58 242.44,22.58 D2.A
  Top 0.305: 239.71,21.49 D2.A
N$99  (via drill 0.25 pad 0.51)
  Top 0.152: IC1.2 249.14,24.03
  Top 0.203: R47.2 247.02,27.3 247.02,24.03 | 247.02,24.03 247.02,23.39 246.68,23.39 | 246.68,23.39 245.34,23.39 C30.1 | 246.68,23.39 246.68,21.93 D2.C v248.56,21.49 | 249.14,24.03 247.02,24.03
  Bottom 0.203: v248.56,21.49 250.04,21.49 C37.+
N$100
  Top 0.203: U$10.7 TP28.TP
N$101
  Top 0.203: R26.1 R47.1 242.85,27.3 U$17.3
N$102
  Top 0.152: R55.2 231.5,31.45 T5.B R54.2
N$103
  Top 0.152: JP2.1 238.25,30.48 | 238.25,30.48 237.95,30.48 237.92,30.51 | 238.25,30.48 237.36,29.59 235.82,29.59 235.67,29.74 T5.C
  Bottom 0.152: JP2.1 238.68,30.48 238.48,30.68 238.48,47.88 238.68,48.08 SV3.2
N$104
  Top 0.152: SV3.1 R56.2
N$105
  Top 0.152: SV3.3 R57.2
N$106
  Top 0.152: SV3.4 246.2,43 246.23,42.98 R58.1 251.85,40.34 T7.C
N$107
  Top 0.152: JP2.2 R22.2
N$108
  Top 0.152: R28.1 R30.2 198.84,11.35 T3.B
N$109
  Top 0.152: R29.1 LED2.C
N$110
  Top 0.152: R29.2 T3.C
N$112
  Top 0.152: 240.43,65.38 239.24,65.38 239.03,65.16 R43.1 | 240.43,65.38 T1.B | 240.43,65.38 C45.2 240.58,63.22 R35.2
N$113
  Top 0.152: SG1.- 237.57,71.2 239.16,69.6 T1.C
N$114  (via drill 0.25 pad 0.51)
  Top 0.152: v164.64,70.69 R48.2 | v164.64,79.86 165.02,80.24 U$19.P7 | v163.47,82.14 162.79,82.14 RN11.8
  Bottom 0.152: v163.47,82.14 163.47,80.92 164.16,80.92 164.16,80.24 164.26,80.24 v164.64,79.86 v164.64,70.69
N$115  (via drill 0.25 pad 0.51)
  Top 0.152: v162.48,70.69 R49.2 | v162.64,78.03 162.65,78.04 U$19.P5 | v161.98,81.74 161.99,81.76 RN11.7
  Bottom 0.152: v162.48,70.69 162.64,70.84 v162.64,78.03 162.64,81.08 v161.98,81.74
N$116  (via drill 0.25 pad 0.51)
  Top 0.152: v160.27,70.69 R50.2 | RN11.6 v161.19,76.03 v161.19,76.02 161.67,76.02 161.85,75.84 U$19.P3
  Bottom 0.152: v161.19,76.02 160.27,75.11 v160.27,70.69
N$117  (via drill 0.25 pad 0.51)
  Top 0.152: v72.01,11.68 v72,11.69 RN12.8 | v67.23,6.5 v67.24,6.5 J1.8
  Bottom 0.152: v67.23,6.5 68.83,6.5 72.01,9.68 v72.01,11.68
N$118
  Top 0.152: J1.6 68.24,8.46 68.44,8.66 72.01,8.66 73.6,10.26 RN12.6
N$119  (via drill 0.25 pad 0.51)
  Top 0.152: v68.73,6.02 68.73,7.16 68.74,7.16 J1.5 | v74.4,8.18 RN12.5
  Bottom 0.152: v74.4,8.18 72.24,6.02 v68.73,6.02
N$120  (via drill 0.25 pad 0.51)
  Top 0.203: R46.2 v240.26,18.54 | v240.26,24.31 U$17.4
  Bottom 0.203: v240.26,18.54 v240.26,24.31
N$123
  Top 0.152: RN12.7 72.8,10.57 71.2,8.97 67.95,8.97 67.74,8.76 J1.7
N$124  (via drill 0.25 pad 0.51)
  Top 0.152: v70.66,11.68 v70.67,11.69 RN13.5 | v66.9,8.53 66.74,8.37 J1.9
  Bottom 0.152: v66.9,8.53 67.51,8.53 v70.66,11.68
N$125
  Top 0.152: RN13.6 69.87,10.08 69.06,9.27 66.65,9.27 66.24,8.86 J1.10
N$126
  Top 0.152: J1.11 65.74,9.17 66.14,9.58 68.28,9.58 69.07,10.37 RN13.7
N$127
  Top 0.152: RN13.8 68.27,10.69 67.46,9.88 65.63,9.88 65.24,9.48 J1.12
N$128
  Top 0.152: RN14.5 66.91,11 66.1,10.19 65.15,10.19 64.74,9.77 J1.13
N$129
  Top 0.152: RN14.6 66.11,11.3 65.3,10.49 64.64,10.49 64.24,10.08 J1.14
N$130  (via drill 0.25 pad 0.51)
  Top 0.152: v65.33,6.5 63.89,6.5 63.74,6.66 J1.15 | v65.33,11.68 65.31,11.7 RN14.7
  Bottom 0.152: v65.33,11.68 v65.33,6.5
N$131
  Top 0.152: J1.16 63.24,10.18 64.51,11.46 RN14.8
N$132
  Top 0.152: J1.17 62.74,10.91 63.15,11.33 RN15.5
N$133
  Top 0.152: RN15.6 62.35,10.58 62.24,10.46 J1.18
N$134
  Top 0.152: RN15.7 61.55,8.97 61.74,8.79 J1.19
N$135
  Top 0.152: RN15.8 60.75,11.48 61.24,11 J1.20
N$136
  Top 0.152: RN16.5 59.39,11.58 60.74,10.24 J1.21
N$137
  Top 0.152: RN16.6 58.59,11.58 60.24,9.93 J1.22
N$138
  Top 0.152: RN16.7 57.79,11.57 59.74,9.63 J1.23
N$139
  Top 0.152: RN16.8 56.99,11.57 59.24,9.32 J1.24
N$140
  Top 0.152: RN17.5 55.61,11.2 57.79,9.02 58.52,9.02 58.74,8.8 J1.25
N$141  (via drill 0.25 pad 0.51)
  Top 0.152: v54.79,11.68 54.81,11.7 RN17.6 | v58.24,8.53 J1.26
  Bottom 0.152: v58.24,8.53 58.24,10.08 56.64,11.68 v54.79,11.68
N$142  (via drill 0.25 pad 0.51)
  Top 0.152: v56.24,8.53 57.58,8.53 57.74,8.38 J1.27 | v54,10.41 v54.01,10.42 RN17.7
  Bottom 0.152: v54,10.41 55.42,10.41 56.24,9.6 v56.24,8.53
N$143  (via drill 0.25 pad 0.51)
  Top 0.152: v58.39,5.99 57.64,5.99 57.24,6.4 J1.28 | v51.99,11.28 52.8,11.28 53.21,11.68 RN17.8
  Bottom 0.152: v51.99,11.28 51.99,7.59 53.59,5.99 v58.39,5.99
N$144  (via drill 0.25 pad 0.51)
  Top 0.152: v52.48,12.09 51.8,12.09 RN18.5 | v56.24,6.5 J1.30
  Bottom 0.152: v56.24,6.5 54.08,6.5 52.48,8.1 v52.48,12.09
N$145
  Top 0.152: RN18.6 51,11.23 52.6,9.63 55.52,9.63 55.74,9.42 J1.31
N$146
  Top 0.152: RN18.7 50.2,10.92 51.8,9.32 55.02,9.32 55.24,9.1 J1.32
N$147
  Top 0.152: RN18.8 49.4,10.62 51,9.02 54.53,9.02 54.74,8.82 J1.33
N$148
  Top 0.152: R51.2 31.78,19.19 31.62,19.03 J3.3
N$149
  Top 0.152: R65.2 30.28,12.84 30.62,12.5 J3.4
NRST  (via drill 0.25 pad 0.51)
  Top 0.152: 160.43,8.79 160.74,8.48 S1.2 v156.77,5.36 | 160.43,8.79 C5.1 159.02,9.62 157.4,11.24 156.63,11.24 v156.62,11.23 | 160.43,8.79 160.74,9.09 v176.53,9.09 | v183.46,28.35 186.83,28.35 186.98,28.19 U1.31 | v88.75,5.36 85.55,2.16 30.23,2.16 28.63,3.76 28.63,5.36 28.62,5.36 J3.6 | v156.62,28.14 156.62,35.05 R9.1
  Bottom 0.152: v183.46,28.35 183.46,15.18 181.86,13.58 179.72,13.58 176.53,10.39 v176.53,9.09 | v156.77,5.36 v88.75,5.36 | v156.62,11.23 v156.62,28.14
PA0
  Top 0.152: TP29.TP 191.46,25.71 191.48,25.73 U1.40
PA1
  Top 0.152: U1.41 191.98,25.18 TP30.TP
PA7  (via drill 0.25 pad 0.51)
  Top 0.152: v198.5,34.24 198.32,34.06 198.32,33.55 TP19.TP | v192.89,35.51 v194.16,35.51 | v192.89,33.05 194.77,33.05 194.79,33.03 U1.53
  Bottom 0.152: v194.16,35.51 197.23,35.51 v198.5,34.24 | v192.89,33.05 v192.89,35.51
PA8
  Top 0.152: U1.119 178.48,53.62 178.51,53.65 178.51,56.24 TP20.TP
PA9
  Top 0.152: U1.120 177.98,53.9 | 177.98,53.9 | 177.98,53.9 TP21.TP
PB2
  Top 0.152: U1.58 196.66,35.53 196.67,35.51 TP22.TP
PB5
  Top 0.152: U1.163 167.78,35.53 TP23.TP
PC0
  Top 0.152: U1.32 TP1.TP
PC1  (via drill 0.25 pad 0.51)
  Top 0.152: v188.8,28.35 188.13,28.35 187.98,28.19 U1.33 | v188.8,24.16 TP2.TP
  Bottom 0.152: v188.8,24.16 v188.8,28.35
PC2
  Top 0.152: U1.34 188.48,25.18 TP5.TP
PC4  (via drill 0.25 pad 0.51)
  Top 0.152: v198.93,32.82 TP3.TP | v194.16,33.53 U1.54
  Bottom 0.152: v194.16,33.53 198.22,33.53 v198.93,32.82
PC5
  Top 0.152: TP10.TP U1.55
PC7
  Top 0.152: U1.116 179.98,53.87 180.04,53.92 TP17.TP
PC8
  Top 0.152: U1.117 179.48,56.26 TP16.TP
PD2
  Top 0.152: U1.144 167.83,45.03 TP24.TP
PD3  (via drill 0.25 pad 0.51)
  Top 0.152: v165.84,44.5 166.52,44.5 TP25.TP | v171.3,44.53 | v171.3,44.53 U1.145
  Bottom 0.152: v171.3,44.53 171.27,44.5 v165.84,44.5
PD4
  Top 0.152: U1.146 167.78,44.03 TP31.TP
PD5
  Top 0.152: U1.147 168.29,43.53 168.28,43.52 166.59,43.52 TP32.TP
PD6
  Top 0.152: U1.150 167.78,42.03 TP11.TP
PD7  (1 unrouted)
  Top 0.152: TP12.TP 167.08,41.53 167.13,41.48 170,41.48 U1.151
PDR_ON
  Top 0.152: R10.2 165.2,29.97 165.61,30.38 165.61,30.71 166.43,31.53 U1.171
PF8
  Top 0.152: TP33.TP 184.43,24.2 184.43,25.69 184.48,25.73 U1.26
PF9
  Top 0.152: U1.27 184.98,25.19 TP34.TP
PG10
  Top 0.152: U1.153 167.78,40.53 TP35.TP
PH1
  Top 0.152: U1.30 186.48,25.84 186.61,25.71 TP47.TP
PH4
  Top 0.152: U1.45 196.67,29.03 TP36.TP
PI3
  Top 0.152: U1.134 167.83,50.03 TP40.TP
PI8
  Top 0.152: U1.7 TP41.TP
PI11
  Top 0.152: U1.13 TP45.TP
POWER_LED  (via drill 0.25 pad 0.51)
  Top 0.152: v189.38,25.04 189.38,25.55 189.23,25.71 189.18,25.71 188.98,25.91 U1.35 | v196.14,13.59 R28.2
  Bottom 0.152: v196.14,13.59 194.23,11.68 190.98,11.68 189.38,13.28 v189.38,25.04
PWM_CPUFAN  (via drill 0.25 pad 0.51)
  Top 0.152: v238.43,10.44 R52.1 | v187.22,23.29 182.58,23.29 182.17,23.7 182.17,24.11 182.58,24.51 183.07,24.51 183.48,24.92 U1.24
  Bottom 0.152: v238.43,10.44 202.72,10.44 199.54,13.61 199.54,24.21 197.94,25.81 197.03,25.81 196.62,25.4 196.62,12.68 195.02,11.07 188.82,11.07 187.22,12.68 v187.22,23.29
PWM_HEATER  (via drill 0.25 pad 0.51)
  Top 0.152: v231.83,34.47 233.48,34.47 R54.1 | v182.96,20.5 v224.69,20.5 | v182.96,24.03 183.55,24.03 183.95,24.44 183.95,27.05 U1.25
  Bottom 0.152: v224.69,20.5 224.69,24.84 231.84,31.99 231.84,34.46 v231.83,34.47 | v182.96,24.03 v182.96,20.5
SCK  (via drill 0.25 pad 0.51)
  Top 0.152: v162.48,47.52 v162.49,47.53 U1.139 | v162.48,67.13 R49.1
  Bottom 0.152: v162.48,67.13 v162.48,47.52
SDCKE1  (via drill 0.25 pad 0.51)
  Top 0.152: v196.75,48.64 196.63,48.53 U1.84 | v197.71,50.32 198.02,50.62 216.97,50.62 217.78,49.81 R15.1
  Bottom 0.152: v197.71,50.32 196.75,49.35 v196.75,48.64
SDCLK
  Top 0.152: U1.112 181.98,57.59 R16.1
SDI  (via drill 0.25 pad 0.51)
  Top 0.152: v164.64,67.13 R48.1 | v168.71,47.02 168.72,47.03 U1.140
  Bottom 0.152: v168.71,47.02 164.64,51.08 v164.64,67.13
SDNCAS
  Top 0.152: U1.160 167.07,37.03 R68.1
SDNE1  (via drill 0.25 pad 0.51)
  Top 0.152: v222.07,30.18 222.07,27.55 R42.1 | v218.74,48.72 218.74,50.11 217.93,50.93 197.64,50.93 197.23,50.52 197.23,48.43 196.82,48.03 U1.83
  Bottom 0.152: v218.74,48.72 222.07,45.39 v222.07,30.18
SDNRAS
  Top 0.152: U1.59 196.58,36.03 196.6,36.04 198.6,36.04 200.2,34.44 200.2,27.63 201.8,26.04 218.67,26.04 219.08,26.44 R67.1
SDNWE
  Top 0.152: U1.46 194.31,29.53 194.16,29.37 194.16,26.8 194.97,25.98 R69.1
SDO  (via drill 0.25 pad 0.51)
  Top 0.152: v160.27,46.53 v160.28,46.53 U1.141 | v160.27,67.13 R50.1
  Bottom 0.152: v160.27,67.13 v160.27,46.53
TCK
  Top 0.152: U1.137 155.32,48.53 154.91,48.12 154.91,42.85 155.07,42.7 R7.1
TDI
  Top 0.152: U1.138 157.02,48.03 156.62,47.62 R3.1
TDO
  Top 0.152: R8.1 156.04,36.47 156.45,36.07 167.61,36.07 168.07,36.53 U1.161
TMS  (via drill 0.25 pad 0.51)
  Top 0.152: v161.14,54.86 175.16,54.86 175.98,54.05 U1.124 | v156.79,45.16 R4.1
  Bottom 0.152: v156.79,45.16 160.33,45.16 161.15,45.97 161.15,54.86 v161.14,54.86
TP_SCL  (via drill 0.25 pad 0.51)
  Top 0.152: R51.1 R36.1 32.59,23.5 29.72,23.5 29.51,23.7 29.51,25.04 29.67,25.2 v59.94,25.2 | v63.45,25.2 160.17,25.2 163.35,28.37 163.35,34.87 163.55,35.08 166.67,35.08 166.75,35.01 170,35.01 U1.164
  Bottom 0.152: v63.45,25.2 v59.94,25.2
TP_SDA  (via drill 0.25 pad 0.51)
  Top 0.152: R65.1 30.43,20.89 30.3,21.02 R41.1 29.32,22.75 28.91,23.17 28.91,25.6 32.08,28.78 140.84,28.78 141.66,29.59 141.66,53.11 143.26,54.71 v155.6,54.71 | v167.18,34.39 v167.17,34.39 167.17,34.53 U1.165
  Bottom 0.152: v167.18,34.39 161.95,34.39 155.6,40.74 v155.6,54.71
TRST  (via drill 0.25 pad 0.51)
  Top 0.152: v156.77,50.32 R1.1 | v168.71,36.02 168.72,36.03 U1.162
  Bottom 0.152: v168.71,36.02 162.61,36.02 156.26,42.37 156.26,49.81 v156.77,50.32
TS_ADDR0  (via drill 0.25 pad 0.51)
  Top 0.152: v201.88,54.66 208.98,54.66 209.79,55.47 IC2.1 | v196.75,46.02 v196.75,46.03 U1.79
  Bottom 0.152: v196.75,46.02 201.07,46.02 201.88,46.84 v201.88,54.66
TS_ADDR1  (via drill 0.25 pad 0.51)
  Top 0.152: v194.16,46.69 194.32,46.53 U1.80 | v200.43,54.1 209.63,54.1 210.44,54.91 IC2.2
  Bottom 0.152: v200.43,54.1 200.43,46.91 200.03,46.51 194.34,46.51 v194.16,46.69
TS_ADDR2
  Top 0.152: U1.92 191.98,53.72 192.18,53.92 194.89,53.92 197.07,56.11 206.6,56.11 207.62,57.12 211.09,57.12 IC2.3
TS_EN  (via drill 0.25 pad 0.51)
  Top 0.152: v189.33,57.71 v189.34,57.7 189.34,57.53 212.63,57.53 213.04,57.12 IC2.6 | v176.28,31.34 174.59,33.03 U1.168
  Bottom 0.152: v176.28,31.34 176.28,54.53 179.45,57.71 v189.33,57.71
TS_SCK  (via drill 0.25 pad 0.51)
  Top 0.152: v207.9,65.33 213.49,65.33 213.64,65.48 U$5.5 214.2,66.73 214.2,67.77 214.4,67.97 218.64,67.97 219.89,66.73 U$6.5 | v192.86,64.92 U$3.5 | v201.07,64.92 201.73,64.92 201.93,65.13 U$4.5 | v191.47,53.8 191.48,53.79 U1.93
  Bottom 0.152: v207.9,65.33 207.9,64.92 v201.07,64.92 v192.86,64.92 191.47,63.53 v191.47,53.8
TS_SDI  (via drill 0.25 pad 0.51)
  Top 0.152: R19.1 227.24,63.6 217.89,63.6 R18.1 217.14,64.47 216.94,64.26 216.94,63.68 216.74,63.47 208.1,63.47 207.04,64.54 R17.1 206.18,63.75 v198.04,63.75 198.04,64.26 197.89,64.41 R27.1 | v194.03,54.41 191.38,54.41 190.98,54 U1.94
  Bottom 0.152: v198.04,63.75 197.21,63.75 194.03,60.58 v194.03,54.41
TS_SDO
  Top 0.152: U1.95 190.48,54.94 TP46.TP
USART2_RX  (via drill 0.25 pad 0.51)
  Top 0.152: v197.1,25.02 194.67,25.02 193.85,25.83 193.85,29.82 194.06,30.03 U1.47 | v181.05,7.62 R24.2
  Bottom 0.152: SV5.2 v181.05,7.62 193.93,7.62 197.1,10.8 v197.1,25.02
USART2_TX  (via drill 0.25 pad 0.51)  (1 unrouted)
  Top 0.152: v178.51,7.62 R23.2 178.51,9.4 184.56,9.4 v186.61,11.46 | v192.48,28.35 v192.48,28.34 U1.42
  Bottom 0.152: v178.51,7.62 SV5.1 | v192.48,28.35 191.52,29.31 188.21,29.31 186.61,27.71 v186.61,11.46
USB_DM  (via drill 0.25 pad 0.51)
  Top 0.152: v173.13,70.94 173.8,70.94 176.98,67.77 U1.122 | v173.13,73.71 v173.12,73.7 159.59,73.7 155.02,78.27 X5.2
  Bottom 0.152: v173.13,73.71 v173.13,70.94
USB_DP
  Top 0.152: X5.3 148.39,77.47 148.18,77.27 148.18,70.41 149.78,68.81 170.1,68.81 176.48,62.44 U1.123
USB_ID
  Top 0.152: X5.4 152.59,76.67 157.66,71.6 174.27,71.6 177.45,68.42 177.45,52.5 U1.121

## Text on the board
tPlace: **DNP** | 4.7uf | 4.7uf | + | + | + | B550 | - | - | + | - | - | 10k | 5.6uH | 0.1uF | RT8289 | 10uF | FB / (100R / @100Mhz) | 0R | *OVEN* | *PCB* | 0.01uF | 0.01uF | 0.01uF | MBR0530 | 10-22uH | .01uf | *USB* | 0.01uF | 0.01uF | BUZZER | 0.01uF | 2.0k | FAN5333B | .01uf | 4.7uf | 4.7uf | 5.6k | 0.01uF | 0.01uF | 0.01uF | 0.01uF | 0.01uF | 0.01uF | MAX31855 | 120k | MAX31855 | MAX31855 | MAX31855 | *1A OR >* | POWER LEDS | 1.0uF | 0.1uF | 0.1uF | NPN | 100R | 10uF | 10uF | 10uF | 10uF | 4.7k | 10uF | 68R | 68R | 68R | 0.1uF | 0.1uF | 3V3 | *MICROSD* | DNP | 20R | 20R | 20R | 20R | 3V3_TP | 5V0 | 390R | 5V0_TP | 240R | 10k | 2.2uf | 33R | 33R | 33R | 74HC138 | CS6 | 4.7uf | 4.7uf | 10k | 4.7uf | CS5 | 1.0uH | 0.1uF | B550 | 0.1uF | CS4 | 5.6uH | PA8 | PC8 | CS7 | 4.7uf | FB / (100R / @100Mhz) | PD12 | .01uF | 10uF | RT8289 | PA9 | PC7 | PG3 | TS_SDO | PD13 | PD11 | 2.2uf | .1uF | LEDS | 0R | 4.7uf | 4.7uf | * | .01uf | 3.16k | .01uf | STLINK/JTAG | PI3 | 0R | 33R | 33R | 20R | 33R | 33R | 33R | 330R | 1.5A - 5x20mm | 120VAC IN | 20R | 20R | PD2 | PD3 | 330R | 10k | 20R | PD5 | PD4 | PD6 | STM32H7 | 0.1uF | 10uF | 10k | PD7 | NPN | PG10 | 64MB SDRAM | PG13 | N-FET | 20R | 0.1uF | HEATER | 33R | *1M - 400V* | PB5 | PB2 | 1k | 10k | 1k | 20R | PC5 | 33R | PC4 | 100R | PA7 | DAC1_OUT2 | 33R | * | 100R | * | 10k | FL5160 | * | PH4 | 2.0k | VOM1271 | 33R | 33R | 33R | 10k | NPN | 80k | 33R | 33R | FAN5333B | NPN | 4.7k | 4.7k | * | PC2 | PA1 | 33R | 12V REG | PE2 | 10uF | N-FET | COOL FAN | PE3 | PE5 | PI8 | PI11 | PF9 | PH1 | PC0 | PA0 | 1.0uF | 1k | 22nF | PE6 | PF8 | PC1 | LOPWR | 470uF | RTC CLOCK | PE4 | 32.768Khz | 10-22uH | MBR0530 | 0.1uF | .01uF | 0.1uF | *1A OR >* | 33R | 4k7 | 1k | 1k | 33R | 33R | 0R | 68R | *DNP* | 4.7uF | 10uF | 68R | 68R | 68R | 68R | 68R | POWER LED | .01uF | 470uF | 470uF | .01uF | 50R | 4.7k | 68R | 2k | 24MHZ CLOCK | 1.0uH | 24Mhz | RESET | BOOT | RS232 | 10k | 1k | CPU FAN | 10uF | 4.7k | 50R | 9VAC IN | .01uF | 0.1uF | 10k | 4.7k | NPN | *1 | 240R | .01uF | 0.1uF | *1 | *1 | 10k | NPN | T962A CONTROLLER V3.0 | FLASH | ROM | TX | RX | GND | 3V3