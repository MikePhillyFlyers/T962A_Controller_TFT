# IAR project T962A_3.0.ewp, settings and files
configuration T962A_3.0 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743II ST STM32H743II
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H743xx
  ICCARM.CCIncludePath2: ../src/testing; ../src/includes; ../src/stm32h7/Drivers/STM32H7xx_HAL_Driver/Inc; ../src/stm32h7/Drivers/CMSIS/Include; ../src/stm32h7/Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../src/stm32h7/Utilities/JPEG; ../src/stm32h7/Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../src/stm32h7/Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../src/stm32h7/Drivers/CMSIS/Include; ../src/stm32h7/Drivers/FatFs/Inc; ../src/stm32h7/Drivers/STemWin/inc; ../src/stm32h7/Drivers/STemWin/Target/Inc; ../src/STemWin/App; ../src/stm32h7/Drivers/FreeRTOS/Inc; ../src/stm32h7/Drivers/FreeRTOS/CM7; ../src/stm32h7/Drivers/FreeRTOS/CM7/IAR; ../src/stm32h7/Drivers/FreeRTOS/Src/CMSIS_RTOS; ../src/stm32h7/Drivers/MinIni
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../src/stm32h7/Drivers/FreeRTOS/Inc
  OBJCOPY.OOCOutputFile: T962A_3.0.hex
  ILINK.IlinkOutputFile: T962A_3.0.out
  ILINK.IlinkIcfFile: ..\Src\stm32h7\stm32h743xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    startup/: startup_stm32h743xx.s
  group Application/includes
    ../Src/includes/: __display_images.h __display_menu_main.h __display_menu_profile.h __display_menu_settings.h buzzer.h common_defs.h coolingfan.h dma2d.h flash.h heartbeat.h heater.h i2c.h init_io.h jpeg.h lcd_draw.h lcd_main.h main.h max31855.h nvstorage.h PID_v1.h reflow.h rtc.h SDcard.h SDcard_Driver.h sensor.h spi.h stm32h7xx_it.h systemfan.h timers.h uart.h usb.h watchdog.h
    ../Src/testing/: __tests.h
  group Application/User
    ../Src/: ___GLOBALS__.c __display_images.c __display_menu_bake.c __display_menu_choosefile.c __display_menu_keyboard.c __display_menu_main.c __display_menu_profile.c __display_menu_profile_draw.c __display_menu_profile_edit.c __display_menu_reflow_run.c __display_menu_settings.c buzzer.c coolingfan.c dma2d.c heartbeat.c heater.c i2c.c init_io.c jpeg.c lcd_draw.c lcd_main.c main.c max31855.c nvstorage.c PID_v1.c reflow.c reflow_profiles.c rtc.c SDcard.c SDcard_Driver.c sdram.c sensor.c spi.c systemfan.c timers.c uart.c usb.c watchdog.c wifi.c
    ../Src/stm32h7/: stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Drivers/CMSIS
    ../Src/stm32h7/: system_stm32h7xx.c
  group Drivers/FATFs
    ../Src/stm32h7/Drivers/FatFs/: ccsbcs.c diskio.c ff.c ff_gen_drv.c syscall.c
  group Drivers/FATFs/includes
    ../Src/stm32h7/Drivers/FatFs/Inc/: diskio.h ff.h ff_gen_drv.h ffconf.h integer.h
  group Drivers/STM32H7xx_HAL_Driver
    ../Src/stm32h7/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_fmc.c stm32h7xx_ll_usb.c
  group Middlewares/FreeRTOS
    ../Src/stm32h7/Drivers/FreeRTOS/Src/: croutine.c event_groups.c list.c queue.c tasks.c timers_rtos.c
  group Middlewares/FreeRTOS/CMIS-RTOS
    ../Src/stm32h7/Drivers/FreeRTOS/Src/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/HAL-TICK
    ../Src/stm32h7/Drivers/FreeRTOS/Src/HAL_TICK/: stm32h7xx_hal_timebase_tim.c
  group Middlewares/FreeRTOS/Portable
    ../Src/stm32h7/Drivers/FreeRTOS/CM7/: heap_4.c
    ../Src/stm32h7/Drivers/FreeRTOS/CM7/IAR/: port.c portasm.s
  group Middlewares/MinIni
    ../Src/stm32h7/Drivers/MinIni/: minIni.c
  group Middlewares/STemWin/Library
    ../Src/stm32h7/Drivers/STemWin/Lib/: STemWin_CM7_OS_wc32_ot_ARGB.a
  group Middlewares/STemWin/OS
    ../Src/stm32h7/Drivers/STemWin/OS/: GUI_X_OS.c
  group Middlewares/STemWin/Target
    ../Src/stm32h7/Drivers/STemWin/Target/: GUIConf.c LCDConf.c
  group Utilities
    ../Src/stm32h7/Utilities/JPEG/: jpeg_utils.c
